v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {blocks/pll/cpump.sym} 190 -160 0 0 {name=x1}
