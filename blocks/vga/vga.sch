v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 290 -660 {}
N 680 -730 680 -670 {lab=VDD}
N 680 -670 990 -670 {lab=VDD}
N 400 -670 680 -670 {lab=VDD}
N 400 -610 400 -590 {lab=#net1}
N 560 -610 560 -570 {lab=Vin1}
N 820 -610 820 -580 {lab=Vin_n1}
N 990 -610 990 -590 {lab=#net2}
N 560 -570 560 -510 {lab=Vin1}
N 820 -580 820 -510 {lab=Vin_n1}
N 560 -510 590 -510 {lab=Vin1}
N 790 -510 820 -510 {lab=Vin_n1}
N 560 -510 560 -460 {lab=Vin1}
N 820 -510 820 -460 {lab=Vin_n1}
N 220 -360 220 -270 {lab=#net1}
N 220 -360 520 -360 {lab=#net1}
N 1140 -360 1140 -270 {lab=#net2}
N 860 -360 1140 -360 {lab=#net2}
N 220 -240 250 -240 {lab=GND}
N 1110 -240 1140 -240 {lab=GND}
N 780 -360 820 -360 {lab=GND}
N 560 -360 590 -360 {lab=GND}
N 560 -330 560 -310 {lab=#net3}
N 560 -310 820 -310 {lab=#net3}
N 820 -330 820 -310 {lab=#net3}
N 690 -280 750 -280 {lab=GND}
N 610 -280 650 -280 {lab=VBB}
N 690 -180 750 -180 {lab=GND}
N 610 -180 650 -180 {lab=VBB2}
N 220 -590 400 -590 {lab=#net1}
N 220 -590 220 -510 {lab=#net1}
N 990 -590 1140 -590 {lab=#net2}
N 1140 -590 1140 -510 {lab=#net2}
N 440 -510 560 -510 {lab=Vin1}
N 440 -520 440 -510 {lab=Vin1}
N 220 -510 380 -510 {lab=#net1}
N 1920 -730 1920 -670 {lab=VDD}
N 1920 -670 2230 -670 {lab=VDD}
N 1640 -670 1920 -670 {lab=VDD}
N 1640 -610 1640 -590 {lab=#net4}
N 1800 -610 1800 -570 {lab=Vout_buf}
N 2060 -610 2060 -580 {lab=Vout_n_buf}
N 2230 -610 2230 -590 {lab=#net5}
N 1800 -570 1800 -510 {lab=Vout_buf}
N 2060 -580 2060 -510 {lab=Vout_n_buf}
N 1800 -510 1830 -510 {lab=Vout_buf}
N 2030 -510 2060 -510 {lab=Vout_n_buf}
N 1800 -510 1800 -460 {lab=Vout_buf}
N 2060 -510 2060 -460 {lab=Vout_n_buf}
N 1460 -350 1460 -260 {lab=#net4}
N 1460 -350 1760 -350 {lab=#net4}
N 1460 -200 2380 -200 {lab=#net6}
N 2380 -350 2380 -260 {lab=#net5}
N 2100 -350 2380 -350 {lab=#net5}
N 1460 -230 1490 -230 {lab=GND}
N 2350 -230 2380 -230 {lab=GND}
N 2020 -350 2060 -350 {lab=GND}
N 1800 -350 1830 -350 {lab=GND}
N 1800 -320 1800 -300 {lab=#net7}
N 1800 -300 2060 -300 {lab=#net7}
N 2060 -320 2060 -300 {lab=#net7}
N 1930 -270 1990 -270 {lab=GND}
N 1850 -270 1890 -270 {lab=VBB}
N 1930 -170 1990 -170 {lab=GND}
N 1850 -170 1890 -170 {lab=VBB2}
N 1460 -590 1640 -590 {lab=#net4}
N 1460 -590 1460 -510 {lab=#net4}
N 2230 -590 2380 -590 {lab=#net5}
N 2380 -590 2380 -510 {lab=#net5}
N 680 -900 680 -880 {lab=GND}
N 310 -1010 340 -1010 {lab=GND}
N 380 -1060 380 -1040 {lab=VDD}
N 380 -1010 430 -1010 {lab=VDD}
N 430 -1060 430 -1010 {lab=VDD}
N 380 -1060 430 -1060 {lab=VDD}
N 180 -580 820 -580 {lab=Vin_n1}
N 180 -580 180 -510 {lab=Vin_n1}
N 560 -570 1180 -570 {lab=Vin1}
N 1180 -570 1180 -510 {lab=Vin1}
N 1420 -580 2060 -580 {lab=Vout_n_buf}
N 1420 -580 1420 -510 {lab=Vout_n_buf}
N 1800 -570 2420 -570 {lab=Vout_buf}
N 2420 -570 2420 -510 {lab=Vout_buf}
N 3320 -490 3440 -490 {lab=Vout_n_buf}
N 3480 -640 3480 -620 {lab=VDD}
N 3480 -460 3480 -420 {lab=#net8}
N 3680 -460 3680 -420 {lab=#net8}
N 3580 -420 3580 -360 {lab=#net8}
N 3650 -330 3680 -330 {lab=#net9}
N 3650 -360 3650 -330 {lab=#net9}
N 3650 -360 3820 -360 {lab=#net9}
N 220 -510 220 -360 {lab=#net1}
N 1140 -510 1140 -360 {lab=#net2}
N 380 -520 380 -510 {lab=#net1}
N 1460 -510 1460 -350 {lab=#net4}
N 2380 -510 2380 -350 {lab=#net5}
N 3620 -330 3650 -330 {lab=#net9}
N 540 -1160 540 -1130 {lab=VDD}
N 680 -1130 700 -1130 {lab=VDD}
N 700 -1160 700 -1130 {lab=VDD}
N 540 -1130 560 -1130 {lab=VDD}
N 540 -1160 620 -1160 {lab=VDD}
N 620 -1160 700 -1160 {lab=VDD}
N 620 -1130 640 -1130 {lab=#net10}
N 620 -1130 620 -1080 {lab=#net10}
N 620 -1080 680 -1080 {lab=#net10}
N 380 -1080 380 -1060 {lab=VDD}
N 620 -1180 620 -1160 {lab=VDD}
N 560 -1060 560 -1040 {lab=VBB}
N 680 -1080 680 -1040 {lab=#net10}
N 620 -1010 640 -1010 {lab=VBB}
N 560 -1060 620 -1060 {lab=VBB}
N 620 -1060 620 -1010 {lab=VBB}
N 620 -1060 720 -1060 {lab=VBB}
N 680 -980 680 -960 {lab=#net11}
N 680 -1010 700 -1010 {lab=GND}
N 700 -1010 700 -880 {lab=GND}
N 680 -880 700 -880 {lab=GND}
N 560 -880 680 -880 {lab=GND}
N 560 -980 560 -880 {lab=GND}
N 540 -880 560 -880 {lab=GND}
N 540 -980 540 -880 {lab=GND}
N 540 -1010 560 -1010 {lab=GND}
N 380 -980 540 -980 {lab=GND}
N 100 -210 100 -110 {lab=#net12}
N 100 -110 1280 -110 {lab=#net12}
N 100 -360 100 -270 {lab=#net1}
N 100 -360 220 -360 {lab=#net1}
N 100 -240 130 -240 {lab=GND}
N 1280 -210 1280 -110 {lab=#net12}
N 1250 -240 1280 -240 {lab=GND}
N 1280 -360 1280 -270 {lab=#net2}
N 1140 -360 1280 -360 {lab=#net2}
N 1360 -900 1360 -880 {lab=GND}
N 990 -1010 1020 -1010 {lab=GND}
N 1060 -1060 1060 -1040 {lab=VDD}
N 1060 -1010 1110 -1010 {lab=VDD}
N 1110 -1060 1110 -1010 {lab=VDD}
N 1060 -1060 1110 -1060 {lab=VDD}
N 1220 -1160 1220 -1130 {lab=VDD}
N 1360 -1130 1380 -1130 {lab=VDD}
N 1380 -1160 1380 -1130 {lab=VDD}
N 1220 -1130 1240 -1130 {lab=VDD}
N 1220 -1160 1300 -1160 {lab=VDD}
N 1300 -1160 1380 -1160 {lab=VDD}
N 1300 -1130 1320 -1130 {lab=#net13}
N 1300 -1130 1300 -1080 {lab=#net13}
N 1300 -1080 1360 -1080 {lab=#net13}
N 1060 -1080 1060 -1060 {lab=VDD}
N 1300 -1180 1300 -1160 {lab=VDD}
N 1240 -1060 1240 -1040 {lab=VBB2}
N 1360 -1080 1360 -1040 {lab=#net13}
N 1300 -1010 1320 -1010 {lab=VBB2}
N 1240 -1060 1300 -1060 {lab=VBB2}
N 1300 -1060 1300 -1010 {lab=VBB2}
N 1300 -1060 1400 -1060 {lab=VBB2}
N 1360 -980 1360 -960 {lab=#net14}
N 1360 -1010 1380 -1010 {lab=GND}
N 1380 -1010 1380 -880 {lab=GND}
N 1360 -880 1380 -880 {lab=GND}
N 1240 -880 1360 -880 {lab=GND}
N 1240 -980 1240 -880 {lab=GND}
N 1220 -880 1240 -880 {lab=GND}
N 1220 -980 1220 -880 {lab=GND}
N 1220 -1010 1240 -1010 {lab=GND}
N 1060 -980 1220 -980 {lab=GND}
N 690 -80 750 -80 {lab=GND}
N 610 -80 650 -80 {lab=VBB2}
N 600 -1130 620 -1130 {lab=#net10}
N 680 -1100 680 -1080 {lab=#net10}
N 560 -1100 560 -1060 {lab=VBB}
N 600 -1010 620 -1010 {lab=VBB}
N 540 -1010 540 -980 {lab=GND}
N 1280 -1130 1300 -1130 {lab=#net13}
N 1360 -1100 1360 -1080 {lab=#net13}
N 1240 -1100 1240 -1060 {lab=VBB2}
N 1280 -1010 1300 -1010 {lab=VBB2}
N 1220 -1010 1220 -980 {lab=GND}
N 3420 -590 3420 -560 {lab=#net15}
N 3420 -560 3480 -560 {lab=#net15}
N 3360 -640 3360 -620 {lab=VDD}
N 3360 -640 3480 -640 {lab=VDD}
N 3720 -590 3720 -560 {lab=#net16}
N 3680 -560 3720 -560 {lab=#net16}
N 3290 -590 3360 -590 {lab=VDD}
N 3290 -640 3290 -590 {lab=VDD}
N 3290 -640 3360 -640 {lab=VDD}
N 3360 -560 3360 -410 {lab=#net17}
N 3360 -350 3360 -300 {lab=GND}
N 3400 -380 3840 -380 {lab=#net17}
N 3720 -330 3760 -330 {lab=GND}
N 3760 -330 3760 -300 {lab=GND}
N 3420 -590 3440 -590 {lab=#net15}
N 3400 -590 3420 -590 {lab=#net15}
N 3720 -590 3840 -590 {lab=#net16}
N 3760 -430 3760 -330 {lab=GND}
N 3880 -590 3950 -590 {lab=VDD}
N 3950 -640 3950 -590 {lab=VDD}
N 3780 -640 3780 -460 {lab=VDD}
N 3480 -420 3680 -420 {lab=#net8}
N 3540 -330 3580 -330 {lab=GND}
N 3680 -560 3680 -520 {lab=#net16}
N 3680 -640 3680 -620 {lab=VDD}
N 3480 -590 3680 -590 {lab=VDD}
N 3580 -640 3580 -590 {lab=VDD}
N 3780 -400 3780 -360 {lab=#net9}
N 3480 -490 3680 -490 {lab=GND}
N 3540 -490 3540 -300 {lab=GND}
N 3720 -490 3750 -490 {lab=Vout_buf}
N 3750 -540 3750 -490 {lab=Vout_buf}
N 3320 -540 3750 -540 {lab=Vout_buf}
N 3480 -560 3480 -520 {lab=#net15}
N 3260 -380 3260 -300 {lab=GND}
N 3260 -380 3360 -380 {lab=GND}
N 3880 -640 3880 -620 {lab=VDD}
N 3880 -380 3980 -380 {lab=GND}
N 3980 -380 3980 -300 {lab=GND}
N 3880 -350 3880 -300 {lab=GND}
N 3880 -560 3880 -410 {lab=Vout_s}
N 3480 -640 3680 -640 {lab=VDD}
N 3680 -640 3880 -640 {lab=VDD}
N 3880 -640 3950 -640 {lab=VDD}
N 3880 -500 4100 -500 {lab=Vout_s}
N 3260 -300 3360 -300 {lab=GND}
N 3360 -300 3580 -300 {lab=GND}
N 3580 -300 3720 -300 {lab=GND}
N 3720 -300 3880 -300 {lab=GND}
N 3880 -300 3980 -300 {lab=GND}
N 3360 -420 3420 -420 {lab=#net17}
N 3420 -420 3420 -380 {lab=#net17}
N 3900 -470 3900 -440 {lab=GND}
N 3900 -440 4040 -440 {lab=GND}
N 220 -210 390 -210 {lab=#net25}
N 450 -210 880 -210 {lab=#net26}
N 940 -210 1140 -210 {lab=#net27}
N 690 -150 910 -190 {lab=GND}
N 420 -190 690 -150 {lab=GND}
N 350 -440 350 -410 {lab=#net1}
N 470 -440 470 -410 {lab=Vin1}
N 380 -390 440 -390 {lab=GND}
N 820 -460 820 -390 {lab=Vin_n1}
N 560 -460 560 -390 {lab=Vin1}
N 470 -510 470 -440 {lab=Vin1}
N 350 -510 350 -440 {lab=#net1}
N 820 -510 940 -510 {lab=Vin_n1}
N 940 -520 940 -510 {lab=Vin_n1}
N 1000 -520 1000 -510 {lab=#net2}
N 910 -440 910 -410 {lab=Vin_n1}
N 1030 -440 1030 -410 {lab=#net2}
N 940 -390 1000 -390 {lab=GND}
N 910 -510 910 -440 {lab=Vin_n1}
N 1030 -510 1030 -440 {lab=#net2}
N 1680 -510 1800 -510 {lab=Vout_buf}
N 1680 -520 1680 -510 {lab=Vout_buf}
N 1460 -510 1620 -510 {lab=#net4}
N 1620 -520 1620 -510 {lab=#net4}
N 1590 -440 1590 -410 {lab=#net4}
N 1710 -440 1710 -410 {lab=Vout_buf}
N 1620 -390 1680 -390 {lab=GND}
N 1710 -510 1710 -440 {lab=Vout_buf}
N 1590 -510 1590 -440 {lab=#net4}
N 2060 -510 2180 -510 {lab=Vout_n_buf}
N 2180 -520 2180 -510 {lab=Vout_n_buf}
N 2240 -520 2240 -510 {lab=#net5}
N 2150 -440 2150 -410 {lab=Vout_n_buf}
N 2270 -440 2270 -410 {lab=#net5}
N 2180 -390 2240 -390 {lab=GND}
N 2150 -510 2150 -440 {lab=Vout_n_buf}
N 2270 -510 2270 -440 {lab=#net5}
N 1000 -510 1140 -510 {lab=#net2}
N 2240 -510 2380 -510 {lab=#net5}
N 2060 -460 2060 -380 {lab=Vout_n_buf}
N 1800 -460 1800 -380 {lab=Vout_buf}
N -190 -250 -90 -250 {lab=Vcp}
N -410 -250 -250 -250 {lab=#net9}
N -630 -250 -470 -250 {lab=#net10}
N -590 -290 -590 -250 {lab=#net10}
N -850 -250 -690 -250 {lab=#net11}
N -810 -290 -810 -250 {lab=#net11}
N -930 -150 -860 -150 {lab=#net12}
N -900 -150 -900 -110 {lab=#net12}
N -800 -150 -640 -150 {lab=#net13}
N -680 -150 -680 -110 {lab=#net13}
N -580 -150 -420 -150 {lab=#net14}
N -460 -150 -460 -110 {lab=#net14}
N -360 -150 -200 -150 {lab=#net15}
N -240 -150 -240 -110 {lab=#net15}
N -880 -210 -110 -210 {lab=GND}
N -880 -230 -880 -80 {lab=GND}
N -830 -320 -830 -210 {lab=GND}
N -830 -210 -830 -170 {lab=GND}
N -660 -210 -660 -80 {lab=GND}
N -660 -230 -660 -210 {lab=GND}
N -610 -320 -610 -210 {lab=GND}
N -610 -210 -610 -170 {lab=GND}
N -440 -210 -440 -80 {lab=GND}
N -440 -230 -440 -210 {lab=GND}
N -390 -210 -390 -170 {lab=GND}
N -220 -210 -220 -80 {lab=GND}
N -220 -230 -220 -210 {lab=GND}
N -170 -210 -170 -170 {lab=GND}
N -930 -250 -910 -250 {lab=#net12}
N -930 -250 -930 -150 {lab=#net12}
N -140 -170 -140 -150 {lab=GND}
N -170 -170 -140 -170 {lab=GND}
N 1750 -960 1910 -960 {lab=Vf_n}
N 1780 -920 1840 -920 {lab=GND}
N 2150 -960 2310 -960 {lab=Vf}
N 2180 -920 2240 -920 {lab=GND}
N 1610 -990 1710 -990 {lab=Vout_buf}
N 1710 -960 1710 -930 {lab=Vf_n}
N 1710 -930 1750 -930 {lab=Vf_n}
N 1750 -960 1750 -930 {lab=Vf_n}
N 2010 -990 2110 -990 {lab=Vout_n_buf}
N 2110 -960 2110 -930 {lab=Vf}
N 2110 -930 2150 -930 {lab=Vf}
N 2150 -960 2150 -930 {lab=Vf}
C {lab_pin.sym} 410 -480 3 0 {name=p3 sig_type=std_logic lab=Vcp

}
C {symbols/nfet_03v3.sym} 540 -360 0 0 {name=M5
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 -360 0 1 {name=M1
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 590 -510 2 0 {name=p15 sig_type=std_logic lab=Vin1
}
C {lab_pin.sym} 790 -510 0 0 {name=p2 sig_type=std_logic lab=Vin_n1
}
C {gnd.sym} 1110 -240 1 0 {name=l4 lab=GND}
C {lab_pin.sym} 610 -280 0 0 {name=p13 sig_type=std_logic lab=VBB

}
C {code_shown.sym} 750 240 0 0 {name=s1 only_toplevel=false spice_ignore=true value="
.include /foss/pdks/gf180mcuD/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice bjt_ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice diode_ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice res_ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice mimcap_ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice moscap_ss
.option method=gear

.control
set temp = -40
  * 1. Setup the sweep parameters
  let v_start = 0
  let v_stop = 3.3
  let v_points = 66
  let v_delta = (v_stop - v_start) / v_points
  
  * 2. Initialize vectors to store results
  let gain_db_20 = unitvec(v_points + 1)
  let gain_db_1200 = unitvec(v_points + 1)
  let vcp_axis = unitvec(v_points + 1)
  
  let i = 0
  while i <= v_points
    let v_current = v_start + (i * v_delta)
    alter v3 = v_current   ; Adjust the Vcp source DC value
    
    * 3. Run AC analysis ONLY at 600MHz to maximize speed
    ac lin 3 0.02G 1.2G
    
    * 4. Calculate Differential Gain in dB
    * Formula: 20 * log10(|Vout_diff| / |Vin_diff|)
    * let vout_mag = mag(v(vout_buf) - v(vout_n_buf))
    let vout_mag = mag(v(vout_s))
    let vin_mag = mag(v(vin) - v(vin_n))
    let g_val = 20 * log10(vout_mag / vin_mag)
    
    * 5. Save results to vectors
    let gain_db_20[i] = g_val[1]
    let gain_db_1200[i] = g_val[2]
    let vcp_axis[i] = v_current
    let i = i + 1
    *print mag(v(vout) - v(vout_n))
    *print i(v1)
  end
  
  * 6. Plot the Gain vs Control Voltage
  plot gain_db_20 gain_db_1200 vs vcp_axis title 'VGA Gain at 20MHz, 1.2GHz vs Vcp, 100fF load' xlabel 'Vcp (V)' ylabel 'Gain (dB)'
.endc
"
}
C {symbols/nfet_03v3.sym} 200 -240 0 0 {name=M16
L=0.28u
W=6u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1160 -240 0 1 {name=M17
L=0.28u
W=6u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 780 -360 1 0 {name=l1 lab=GND}
C {gnd.sym} 590 -360 3 1 {name=l15 lab=GND}
C {gnd.sym} 250 -240 3 1 {name=l16 lab=GND}
C {symbols/nfet_03v3.sym} 670 -280 0 0 {name=M2
L=0.28u
W=24u
nf=12
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 750 -280 3 1 {name=l2 lab=GND}
C {gnd.sym} 690 -250 0 0 {name=l9 lab=GND}
C {lab_pin.sym} 610 -180 0 0 {name=p6 sig_type=std_logic lab=VBB2
}
C {symbols/nfet_03v3.sym} 670 -180 0 0 {name=M4
L=0.28u
W=12u
nf=6
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 750 -180 3 1 {name=l11 lab=GND}
C {gnd.sym} 690 -150 0 0 {name=l12 lab=GND}
C {symbols/pfet_03v3.sym} 410 -500 3 0 {name=M9
L=0.28u
W=10u
nf=5
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 410 -520 1 0 {name=p16 sig_type=std_logic lab=VDD
}
C {symbols/nfet_03v3.sym} 1780 -350 0 0 {name=M6
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2080 -350 0 1 {name=M7
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1920 -730 0 0 {name=p19 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 1830 -510 2 0 {name=p20 sig_type=std_logic lab=Vout_buf
}
C {lab_pin.sym} 2030 -510 0 0 {name=p21 sig_type=std_logic lab=Vout_n_buf
}
C {lab_pin.sym} 2420 -230 0 1 {name=p22 sig_type=std_logic lab=Vin_n1
}
C {lab_pin.sym} 1420 -230 0 0 {name=p23 sig_type=std_logic lab=Vin1
}
C {gnd.sym} 2350 -230 1 0 {name=l13 lab=GND}
C {lab_pin.sym} 1850 -270 0 0 {name=p24 sig_type=std_logic lab=VBB}
C {symbols/nfet_03v3.sym} 1440 -230 0 0 {name=M8
L=0.28u
W=10u
nf=5
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2400 -230 0 1 {name=M10
L=0.28u
W=10u
nf=5
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2020 -350 1 0 {name=l14 lab=GND}
C {gnd.sym} 1830 -350 3 1 {name=l17 lab=GND}
C {gnd.sym} 1490 -230 3 1 {name=l18 lab=GND}
C {symbols/nfet_03v3.sym} 1910 -270 0 0 {name=M11
L=0.28u
W=24u
nf=12
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1990 -270 3 1 {name=l19 lab=GND}
C {gnd.sym} 1930 -240 0 0 {name=l20 lab=GND}
C {lab_pin.sym} 1850 -170 0 0 {name=p25 sig_type=std_logic lab=VBB2}
C {symbols/nfet_03v3.sym} 1910 -170 0 0 {name=M12
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1990 -170 3 1 {name=l21 lab=GND}
C {gnd.sym} 1930 -140 0 0 {name=l22 lab=GND}
C {symbols/pfet_03v3.sym} 580 -1130 0 1 {name=M21
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 660 -1130 0 0 {name=M22
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 620 -1180 0 0 {name=p37 sig_type=std_logic lab=VDD
}
C {symbols/nfet_03v3.sym} 580 -1010 0 1 {name=M23
L=1.12u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 660 -1010 0 0 {name=M24
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 680 -880 0 0 {name=l30 lab=GND}
C {lab_pin.sym} 720 -1060 0 1 {name=p38 sig_type=std_logic lab=VBB
}
C {symbols/pfet_03v3.sym} 360 -1010 0 0 {name=M25
L=5.6u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gnd.sym} 310 -1010 0 0 {name=l31 lab=GND}
C {lab_pin.sym} 380 -1080 0 0 {name=p39 sig_type=std_logic lab=VDD
}
C {gnd.sym} 540 -640 0 1 {name=l8 lab=GND}
C {gnd.sym} 800 -640 0 1 {name=l33 lab=GND}
C {gnd.sym} 410 -390 0 1 {name=l34 lab=GND}
C {gnd.sym} 1780 -640 0 1 {name=l38 lab=GND}
C {gnd.sym} 2040 -640 0 1 {name=l39 lab=GND}
C {gnd.sym} 380 -640 0 1 {name=l41 lab=GND}
C {gnd.sym} 970 -640 0 1 {name=l42 lab=GND}
C {symbols/ppolyf_u_1k.sym} 680 -930 0 1 {name=R4
W=1e-6
L=1.4e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {gnd.sym} 1620 -640 0 1 {name=l43 lab=GND}
C {gnd.sym} 2210 -640 0 1 {name=l44 lab=GND}
C {code_shown.sym} -750 190 0 0 {name=s2 only_toplevel=false spice_ignore=true value="
.include /foss/pdks/gf180mcuD/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice bjt_ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice diode_ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice res_ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice mimcap_ss
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice moscap_ss
.option method=gear

.control
set temp = 85

* this one is for conducting instantaneous power vs. time (transient analysis)
let freq = 1200meg
let pers = 100
let steps = 2000

let tper = 1 / freq
let tfin = pers * tper
let tstep = tfin / steps

let amp = 10m
let plotst = tfin - 2 * tper
let postamp = 5 * amp

alter @v6[sin] = [ 1.65 $&amp $&freq 0 0 0 ]
alter @v7[sin] = [ 1.65 $&amp $&freq 0 0 180 ]

* alter @v4[sin] = [ 1.65 $&postamp $&freq 0 0 0 ]
* alter @v8[sin] = [ 1.65 $&postamp $&freq 0 0 180 ]

tran $&tstep $&tfin
plot v(vout_s) v(vout_buf) v(vout_n_buf) v(vin1) v(vin_n1) v(vin) v(vin_n) xlimit $&plotst $&tfin
plot v(vf) v(vf_n) v(vbb) v(vbb2)

* let abc = v(vout_s)
* plot abc v(net9) v(net14) xlimit $&plotst $&tfin

let pwr = -1 * v1#branch * vdd
plot pwr ylimit 0 60m
.endc
"
}
C {symbols/nfet_03v3.sym} 200 -510 0 0 {name=M26
L=0.42u
W=4u
nf=2
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1160 -510 0 1 {name=M27
L=0.42u
W=4u
nf=2
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1440 -510 0 0 {name=M28
L=0.42u
W=4u
nf=2
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2400 -510 0 1 {name=M29
L=0.42u
W=4u
nf=2
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3460 -590 0 0 {name=M_inv1
L=0.28u
W=10u
nf=20
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 3580 -640 1 0 {name=p4 sig_type=std_logic lab=VDD
}
C {gnd.sym} 3580 -300 0 0 {name=l45 lab=GND}
C {symbols/nfet_03v3.sym} 3460 -490 0 0 {name=M_inv1n
L=0.28u
W=24u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3700 -590 0 1 {name=M_inv2
L=0.28u
W=10u
nf=20
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 -490 0 1 {name=M_inv2n
L=0.28u
W=24u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3600 -330 0 1 {name=Mtail1
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 -330 0 0 {name=Mtail2
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {code_shown.sym} 2170 360 0 0 {name=s3 only_toplevel=false spice_ignore=false value="
.include /foss/pdks/gf180mcuD/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice bjt_typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice diode_typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice res_typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice mimcap_typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice moscap_typical
.option method=gear

.control
set temp = 25
  * 1. Setup the sweep parameters
  let v_ctrl = 0.6

  let f_start = 1
  let f_stop = 3.2G
  let f_points = 120
  
  * 2. Initialize vectors to store results
  let gain_db = unitvec(f_points)
  
  alter v3 = v_ctrl
  ac dec $&f_points $&f_start $&f_stop
    
  * 4. Calculate Differential Gain in dB
  * Formula: 20 * log10(|Vout_diff| / |Vin_diff|)
  let vin_mag = mag(v(vin) - v(vin_n))
  let vout_s_mag = mag(v(vout_s))
  let vout_buf_mag = mag(v(vout_buf) - v(vout_n_buf))
  let vout_s_gain = 20 * log10(vout_s_mag / vin_mag)
  let vout_buf_gain = 20 * log10(vout_buf_mag / vin_mag)

  * Credit to marcel hendrix
  * https://sourceforge.net/p/ngspice/discussion/133842/thread/2031ad61/
  meas ac peak  MAX  vmag(vout_s) FROM=$&f_start TO=$&f_stop
  let f3db = peak/sqrt(2)
  meas ac lo_3db WHEN vmag(vout_s)=f3db RISE=1
  meas ac hi_3db WHEN vmag(vout_s)=f3db FALL=1
  
  * 5. Save results to vectors
  plot vout_s_gain vout_buf_gain title 'Gain (dB) vs. Frequency from 1MHz to 3.2GHz, 0.6 vctrl' ylimit 0 80
.endc
"
}
C {symbols/nfet_03v3.sym} 80 -240 0 0 {name=M36
L=0.28u
W=4u
nf=2
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 60 -240 0 0 {name=p41 sig_type=std_logic lab=Vf}
C {gnd.sym} 130 -240 3 1 {name=l32 lab=GND}
C {symbols/nfet_03v3.sym} 1300 -240 0 1 {name=M38
L=0.28u
W=4u
nf=2
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1250 -240 1 0 {name=l40 lab=GND}
C {lab_pin.sym} 1320 -240 0 1 {name=p42 sig_type=std_logic lab=Vf_n}
C {symbols/pfet_03v3.sym} 1260 -1130 0 1 {name=M37
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1340 -1130 0 0 {name=M41
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1300 -1180 0 0 {name=p40 sig_type=std_logic lab=VDD
}
C {symbols/nfet_03v3.sym} 1260 -1010 0 1 {name=M42
L=1.12u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1340 -1010 0 0 {name=M43
L=0.28u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1360 -880 0 0 {name=l29 lab=GND}
C {lab_pin.sym} 1400 -1060 0 1 {name=p47 sig_type=std_logic lab=VBB2}
C {symbols/pfet_03v3.sym} 1040 -1010 0 0 {name=M44
L=5.6u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {gnd.sym} 990 -1010 0 0 {name=l51 lab=GND}
C {lab_pin.sym} 1060 -1080 0 0 {name=p48 sig_type=std_logic lab=VDD
}
C {symbols/ppolyf_u_1k.sym} 1360 -930 0 1 {name=R19
W=1e-6
L=1.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_pin.sym} 610 -80 0 0 {name=p49 sig_type=std_logic lab=VBB2
}
C {symbols/nfet_03v3.sym} 670 -80 0 0 {name=M45
L=0.28u
W=8u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 750 -80 3 1 {name=l52 lab=GND}
C {vsource.sym} 3820 -330 0 0 {name=V_bias value="dc 2.4" savecurrent=false spice_ignore=true}
C {symbols/pfet_03v3.sym} 3380 -590 0 1 {name=Mmir1l
L=0.28u
W=28u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3860 -590 0 0 {name=Mmir1r
L=0.28u
W=28u
nf=4
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3380 -380 0 1 {name=Mmir2l
L=0.28u
W=12u
nf=6
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3860 -380 0 0 {name=Mmir2r
L=0.28u
W=12u
nf=6
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/ppolyf_u_1k.sym} 3780 -430 0 0 {name=R_bias
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=2}
C {lab_pin.sym} 3320 -540 0 0 {name=p35 sig_type=std_logic lab=Vout_buf}
C {lab_pin.sym} 3320 -490 0 0 {name=p36 sig_type=std_logic lab=Vout_n_buf}
C {capa-2.sym} 4040 -470 0 0 {name=C_load
m=1
value=100f
footprint=1206
device=polarized_capacitor}
C {gnd.sym} 4040 -440 0 0 {name=l46 lab=GND}
C {symbols/ppolyf_u_1k.sym} 420 -210 1 1 {name=R35
W=1e-6
L=2.3e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 910 -210 1 1 {name=R36
W=1e-6
L=2.3e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 380 -410 1 1 {name=R5
W=1e-6
L=7.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 440 -410 3 0 {name=R17
W=1e-6
L=7.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_pin.sym} 970 -480 1 1 {name=p7 sig_type=std_logic lab=Vcp

}
C {symbols/pfet_03v3.sym} 970 -500 1 1 {name=M3
L=0.28u
W=10u
nf=5
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 970 -520 3 1 {name=p8 sig_type=std_logic lab=VDD
}
C {gnd.sym} 970 -390 0 1 {name=l7 lab=GND}
C {symbols/ppolyf_u_1k.sym} 940 -410 1 1 {name=R15
W=1e-6
L=7.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 1000 -410 3 0 {name=R18
W=1e-6
L=7.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_pin.sym} 1650 -480 3 0 {name=p17 sig_type=std_logic lab=Vcp

}
C {symbols/pfet_03v3.sym} 1650 -500 3 0 {name=M13
L=0.28u
W=10u
nf=5
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1650 -520 1 0 {name=p18 sig_type=std_logic lab=VDD
}
C {gnd.sym} 1650 -390 0 1 {name=l35 lab=GND}
C {symbols/ppolyf_u_1k.sym} 1620 -410 1 1 {name=R9
W=1e-6
L=7.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 1680 -410 3 0 {name=R11
W=1e-6
L=7.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_pin.sym} 2210 -480 1 1 {name=p26 sig_type=std_logic lab=Vcp

}
C {symbols/pfet_03v3.sym} 2210 -500 1 1 {name=M14
L=0.28u
W=10u
nf=5
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2210 -520 3 1 {name=p27 sig_type=std_logic lab=VDD
}
C {gnd.sym} 2210 -390 0 1 {name=l36 lab=GND}
C {symbols/ppolyf_u_1k.sym} 2180 -410 1 1 {name=R37
W=1e-6
L=7.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2240 -410 3 0 {name=R38
W=1e-6
L=7.8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 3920 -470 0 0 {name=Rload
W=1e-6
L=2.3e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 560 -640 0 0 {name=R1
W=1e-6
L=2.9e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 820 -640 0 0 {name=R12
W=1e-6
L=2.9e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 1800 -640 0 0 {name=R6
W=1e-6
L=2.9e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2060 -640 0 0 {name=R7
W=1e-6
L=2.9e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 990 -640 0 0 {name=R3
W=1e-6
L=5.3e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 400 -640 0 0 {name=R2
W=1e-6
L=5.3e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 1640 -640 0 0 {name=R8
W=1e-6
L=5.3e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2230 -640 0 0 {name=R10
W=1e-6
L=5.3e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_pin.sym} -90 -250 2 0 {name=p28 sig_type=std_logic lab=Vcp

}
C {symbols/ppolyf_u_1k.sym} -220 -250 1 1 {name=R39
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -440 -250 1 1 {name=R40
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -660 -250 1 1 {name=R41
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -590 -320 2 1 {name=R42
W=1e-6
L=2.2e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -880 -250 1 1 {name=R43
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -810 -320 2 1 {name=R44
W=1e-6
L=2.2e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -830 -150 3 1 {name=R45
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -900 -80 0 1 {name=R46
W=1e-6
L=2.2e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -610 -150 3 1 {name=R47
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -680 -80 0 1 {name=R48
W=1e-6
L=2.2e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -390 -150 3 1 {name=R49
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -460 -80 0 1 {name=R50
W=1e-6
L=2.2e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -170 -150 3 1 {name=R51
W=1e-6
L=2.2e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} -240 -80 0 1 {name=R52
W=1e-6
L=2.2e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {gnd.sym} -110 -210 3 0 {name=l37 lab=GND}
C {ipin.sym} -240 -50 2 0 {name=p61 lab=Vcp_0}
C {ipin.sym} -460 -50 2 0 {name=p62 lab=Vcp_1}
C {ipin.sym} -680 -50 2 0 {name=p63 lab=Vcp_2}
C {ipin.sym} -900 -50 2 0 {name=p64 lab=Vcp_3}
C {ipin.sym} -810 -350 2 0 {name=p65 lab=Vcp_4}
C {ipin.sym} -590 -350 2 0 {name=p66 lab=Vcp_5}
C {ipin.sym} 180 -240 0 0 {name=p1 lab=Vin
}
C {ipin.sym} 1180 -240 0 1 {name=p5 lab=Vin_n
}
C {lab_pin.sym} 1610 -990 0 0 {name=p9 sig_type=std_logic lab=Vout_buf}
C {symbols/nfet_03v3.sym} 1810 -940 1 0 {name=M19
L=0.56u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1810 -920 0 0 {name=l3 lab=GND}
C {lab_pin.sym} 1910 -960 0 1 {name=p10 sig_type=std_logic lab=Vf_n}
C {lab_pin.sym} 2010 -990 0 0 {name=p12 sig_type=std_logic lab=Vout_n_buf}
C {symbols/nfet_03v3.sym} 2210 -940 1 0 {name=M20
L=0.56u
W=20u
nf=10
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2210 -920 0 0 {name=l5 lab=GND}
C {lab_pin.sym} 2310 -960 0 1 {name=p29 sig_type=std_logic lab=Vf}
C {symbols/nfet_03v3.sym} 1730 -960 0 1 {name=M30
L=0.28u
W=0.88u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2130 -960 0 1 {name=M31
L=0.28u
W=0.88u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {ipin.sym} 680 -730 2 0 {name=p30 lab=VDD}
C {opin.sym} 4100 -500 0 0 {name=p14 lab=Vout_s
}
C {ipin.sym} 690 -50 0 1 {name=p11 lab=GND
}
