v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 2010 -720 2810 -320 {flags=graph
y1=-0.026
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.1231753e-08
x2=4.311607e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="b0
b1
b2
b3
b4
b5"
color="7 4 6 10 13 15"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 2010 -1160 2810 -760 {flags=graph
y1=-0.66
y2=2.64
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.1231753e-08
x2=4.311607e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="clk_eval
clk_pre"
color="4 7"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 2010 -1610 2810 -1210 {flags=graph
y1=0
y2=3.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.1231753e-08
x2=4.311607e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="in0
in1
in2
in3
in4
in5
in6"
color="4 5 6 7 8 10 11"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 2010 -320 2810 80 {flags=graph
y1=-0.026
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.1231753e-08
x2=4.311607e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color=12
node=b}
N 4600 -4440 4600 -4420 {lab=VDD}
N 4595 -4390 4610 -4390 {lab=VDD}
N 4600 -4240 4600 -4220 {lab=FOOT}
N 4600 -4270 4620 -4270 {lab=GND}
N 4600 -3960 4600 -3940 {lab=FOOT}
N 4600 -3990 4620 -3990 {lab=GND}
N 4600 -3680 4600 -3660 {lab=FOOT}
N 4600 -3710 4620 -3710 {lab=GND}
N 4400 -3960 4400 -3940 {lab=FOOT}
N 4400 -3990 4420 -3990 {lab=GND}
N 4400 -4100 4400 -4080 {lab=FOOT}
N 4400 -4130 4420 -4130 {lab=GND}
N 4400 -3540 4400 -3520 {lab=FOOT}
N 4400 -3570 4420 -3570 {lab=GND}
N 4600 -3400 4600 -3380 {lab=FOOT}
N 4600 -3430 4620 -3430 {lab=GND}
N 4400 -3400 4400 -3380 {lab=FOOT}
N 4400 -3430 4420 -3430 {lab=GND}
N 4200 -3680 4200 -3660 {lab=FOOT}
N 4200 -3710 4220 -3710 {lab=GND}
N 4200 -3820 4200 -3800 {lab=FOOT}
N 4200 -3850 4220 -3850 {lab=GND}
N 4200 -3400 4200 -3380 {lab=FOOT}
N 4200 -3430 4220 -3430 {lab=GND}
N 4200 -3540 4200 -3520 {lab=FOOT}
N 4200 -3570 4220 -3570 {lab=GND}
N 4600 -3120 4600 -3100 {lab=FOOT}
N 4600 -3150 4620 -3150 {lab=GND}
N 4600 -2840 4600 -2820 {lab=FOOT}
N 4600 -2870 4620 -2870 {lab=GND}
N 4600 -2560 4600 -2540 {lab=FOOT}
N 4600 -2590 4620 -2590 {lab=GND}
N 4400 -2840 4400 -2820 {lab=FOOT}
N 4400 -2870 4420 -2870 {lab=GND}
N 4400 -2980 4400 -2960 {lab=FOOT}
N 4400 -3010 4420 -3010 {lab=GND}
N 4400 -2420 4400 -2400 {lab=FOOT}
N 4400 -2450 4420 -2450 {lab=GND}
N 4600 -2280 4600 -2260 {lab=FOOT}
N 4600 -2310 4620 -2310 {lab=GND}
N 4400 -2280 4400 -2260 {lab=FOOT}
N 4400 -2310 4420 -2310 {lab=GND}
N 4200 -2560 4200 -2540 {lab=FOOT}
N 4200 -2590 4220 -2590 {lab=GND}
N 4200 -2700 4200 -2680 {lab=FOOT}
N 4200 -2730 4220 -2730 {lab=GND}
N 4200 -2280 4200 -2260 {lab=FOOT}
N 4200 -2310 4220 -2310 {lab=GND}
N 4200 -2420 4200 -2400 {lab=FOOT}
N 4200 -2450 4220 -2450 {lab=GND}
N 4000 -3120 4000 -3100 {lab=FOOT}
N 4000 -3150 4020 -3150 {lab=GND}
N 4000 -3260 4000 -3240 {lab=FOOT}
N 4000 -3290 4020 -3290 {lab=GND}
N 4000 -2840 4000 -2820 {lab=FOOT}
N 4000 -2870 4020 -2870 {lab=GND}
N 4000 -2980 4000 -2960 {lab=FOOT}
N 4000 -3010 4020 -3010 {lab=GND}
N 4000 -2560 4000 -2540 {lab=FOOT}
N 4000 -2590 4020 -2590 {lab=GND}
N 4000 -2700 4000 -2680 {lab=FOOT}
N 4000 -2730 4020 -2730 {lab=GND}
N 4000 -2280 4000 -2260 {lab=FOOT}
N 4000 -2310 4020 -2310 {lab=GND}
N 4000 -2420 4000 -2400 {lab=FOOT}
N 4000 -2450 4020 -2450 {lab=GND}
N 3800 -2140 3800 -2120 {lab=FOOT}
N 3800 -2170 3820 -2170 {lab=GND}
N 4600 -2000 4600 -1980 {lab=FOOT}
N 4600 -2030 4620 -2030 {lab=GND}
N 4600 -1720 4600 -1700 {lab=FOOT}
N 4600 -1750 4620 -1750 {lab=GND}
N 4600 -1440 4600 -1420 {lab=FOOT}
N 4600 -1470 4620 -1470 {lab=GND}
N 4400 -1720 4400 -1700 {lab=FOOT}
N 4400 -1750 4420 -1750 {lab=GND}
N 4400 -1860 4400 -1840 {lab=FOOT}
N 4400 -1890 4420 -1890 {lab=GND}
N 4400 -1300 4400 -1280 {lab=FOOT}
N 4400 -1330 4420 -1330 {lab=GND}
N 4600 -1160 4600 -1140 {lab=FOOT}
N 4600 -1190 4620 -1190 {lab=GND}
N 4400 -1160 4400 -1140 {lab=FOOT}
N 4400 -1190 4420 -1190 {lab=GND}
N 4200 -1440 4200 -1420 {lab=FOOT}
N 4200 -1470 4220 -1470 {lab=GND}
N 4200 -1580 4200 -1560 {lab=FOOT}
N 4200 -1610 4220 -1610 {lab=GND}
N 4200 -1160 4200 -1140 {lab=FOOT}
N 4200 -1190 4220 -1190 {lab=GND}
N 4200 -1300 4200 -1280 {lab=FOOT}
N 4200 -1330 4220 -1330 {lab=GND}
N 4600 -880 4600 -860 {lab=FOOT}
N 4600 -910 4620 -910 {lab=GND}
N 4600 -600 4600 -580 {lab=FOOT}
N 4600 -630 4620 -630 {lab=GND}
N 4600 -320 4600 -300 {lab=FOOT}
N 4600 -350 4620 -350 {lab=GND}
N 4400 -600 4400 -580 {lab=FOOT}
N 4400 -630 4420 -630 {lab=GND}
N 4400 -740 4400 -720 {lab=FOOT}
N 4400 -770 4420 -770 {lab=GND}
N 4400 -180 4400 -160 {lab=FOOT}
N 4400 -210 4420 -210 {lab=GND}
N 4600 -40 4600 -20 {lab=FOOT}
N 4600 -70 4620 -70 {lab=GND}
N 4400 -40 4400 -20 {lab=FOOT}
N 4400 -70 4420 -70 {lab=GND}
N 4200 -320 4200 -300 {lab=FOOT}
N 4200 -350 4220 -350 {lab=GND}
N 4200 -460 4200 -440 {lab=FOOT}
N 4200 -490 4220 -490 {lab=GND}
N 4200 -40 4200 -20 {lab=FOOT}
N 4200 -70 4220 -70 {lab=GND}
N 4200 -180 4200 -160 {lab=FOOT}
N 4200 -210 4220 -210 {lab=GND}
N 4000 -880 4000 -860 {lab=FOOT}
N 4000 -910 4020 -910 {lab=GND}
N 4000 -1020 4000 -1000 {lab=FOOT}
N 4000 -1050 4020 -1050 {lab=GND}
N 4000 -600 4000 -580 {lab=FOOT}
N 4000 -630 4020 -630 {lab=GND}
N 4000 -740 4000 -720 {lab=FOOT}
N 4000 -770 4020 -770 {lab=GND}
N 4000 -320 4000 -300 {lab=FOOT}
N 4000 -350 4020 -350 {lab=GND}
N 4000 -460 4000 -440 {lab=FOOT}
N 4000 -490 4020 -490 {lab=GND}
N 4000 -40 4000 -20 {lab=FOOT}
N 4000 -70 4020 -70 {lab=GND}
N 4000 -180 4000 -160 {lab=FOOT}
N 4000 -210 4020 -210 {lab=GND}
N 4600 240 4600 260 {lab=FOOT}
N 4600 210 4620 210 {lab=GND}
N 4600 520 4600 540 {lab=FOOT}
N 4600 490 4620 490 {lab=GND}
N 4600 800 4600 820 {lab=FOOT}
N 4600 770 4620 770 {lab=GND}
N 4400 520 4400 540 {lab=FOOT}
N 4400 490 4420 490 {lab=GND}
N 4400 380 4400 400 {lab=FOOT}
N 4400 350 4420 350 {lab=GND}
N 4400 940 4400 960 {lab=FOOT}
N 4400 910 4420 910 {lab=GND}
N 4600 1080 4600 1100 {lab=FOOT}
N 4600 1050 4620 1050 {lab=GND}
N 4400 1080 4400 1100 {lab=FOOT}
N 4400 1050 4420 1050 {lab=GND}
N 4200 800 4200 820 {lab=FOOT}
N 4200 770 4220 770 {lab=GND}
N 4200 660 4200 680 {lab=FOOT}
N 4200 630 4220 630 {lab=GND}
N 4200 1080 4200 1100 {lab=FOOT}
N 4200 1050 4220 1050 {lab=GND}
N 4200 940 4200 960 {lab=FOOT}
N 4200 910 4220 910 {lab=GND}
N 4600 1360 4600 1380 {lab=FOOT}
N 4600 1330 4620 1330 {lab=GND}
N 4600 1640 4600 1660 {lab=FOOT}
N 4600 1610 4620 1610 {lab=GND}
N 4600 1920 4600 1940 {lab=FOOT}
N 4600 1890 4620 1890 {lab=GND}
N 4400 1640 4400 1660 {lab=FOOT}
N 4400 1610 4420 1610 {lab=GND}
N 4400 1500 4400 1520 {lab=FOOT}
N 4400 1470 4420 1470 {lab=GND}
N 4400 2060 4400 2080 {lab=FOOT}
N 4400 2030 4420 2030 {lab=GND}
N 4600 2200 4600 2220 {lab=FOOT}
N 4600 2170 4620 2170 {lab=GND}
N 4400 2200 4400 2220 {lab=FOOT}
N 4400 2170 4420 2170 {lab=GND}
N 4200 1920 4200 1940 {lab=FOOT}
N 4200 1890 4220 1890 {lab=GND}
N 4200 1780 4200 1800 {lab=FOOT}
N 4200 1750 4220 1750 {lab=GND}
N 4200 2200 4200 2220 {lab=FOOT}
N 4200 2170 4220 2170 {lab=GND}
N 4200 2060 4200 2080 {lab=FOOT}
N 4200 2030 4220 2030 {lab=GND}
N 4000 1360 4000 1380 {lab=FOOT}
N 4000 1330 4020 1330 {lab=GND}
N 4000 1220 4000 1240 {lab=FOOT}
N 4000 1190 4020 1190 {lab=GND}
N 4000 1640 4000 1660 {lab=FOOT}
N 4000 1610 4020 1610 {lab=GND}
N 4000 1500 4000 1520 {lab=FOOT}
N 4000 1470 4020 1470 {lab=GND}
N 4000 1920 4000 1940 {lab=FOOT}
N 4000 1890 4020 1890 {lab=GND}
N 4000 1780 4000 1800 {lab=FOOT}
N 4000 1750 4020 1750 {lab=GND}
N 4000 2200 4000 2220 {lab=FOOT}
N 4000 2170 4020 2170 {lab=GND}
N 4000 2060 4000 2080 {lab=FOOT}
N 4000 2030 4020 2030 {lab=GND}
N 4600 2480 4600 2500 {lab=FOOT}
N 4600 2450 4620 2450 {lab=GND}
N 4600 2760 4600 2780 {lab=FOOT}
N 4600 2730 4620 2730 {lab=GND}
N 4600 3040 4600 3060 {lab=FOOT}
N 4600 3010 4620 3010 {lab=GND}
N 4400 2760 4400 2780 {lab=FOOT}
N 4400 2730 4420 2730 {lab=GND}
N 4400 2620 4400 2640 {lab=FOOT}
N 4400 2590 4420 2590 {lab=GND}
N 4400 3180 4400 3200 {lab=FOOT}
N 4400 3150 4420 3150 {lab=GND}
N 4600 3320 4600 3340 {lab=FOOT}
N 4600 3290 4620 3290 {lab=GND}
N 4400 3320 4400 3340 {lab=FOOT}
N 4400 3290 4420 3290 {lab=GND}
N 4200 3040 4200 3060 {lab=FOOT}
N 4200 3010 4220 3010 {lab=GND}
N 4200 2900 4200 2920 {lab=FOOT}
N 4200 2870 4220 2870 {lab=GND}
N 4200 3320 4200 3340 {lab=FOOT}
N 4200 3290 4220 3290 {lab=GND}
N 4200 3180 4200 3200 {lab=FOOT}
N 4200 3150 4220 3150 {lab=GND}
N 4600 3600 4600 3620 {lab=FOOT}
N 4600 3570 4620 3570 {lab=GND}
N 4600 3880 4600 3900 {lab=FOOT}
N 4600 3850 4620 3850 {lab=GND}
N 4600 4160 4600 4180 {lab=FOOT}
N 4600 4130 4620 4130 {lab=GND}
N 4400 3880 4400 3900 {lab=FOOT}
N 4400 3850 4420 3850 {lab=GND}
N 4400 3740 4400 3760 {lab=FOOT}
N 4400 3710 4420 3710 {lab=GND}
N 4400 4300 4400 4320 {lab=FOOT}
N 4400 4270 4420 4270 {lab=GND}
N 4600 4440 4600 4460 {lab=FOOT}
N 4600 4410 4620 4410 {lab=GND}
N 4400 4440 4400 4460 {lab=FOOT}
N 4400 4410 4420 4410 {lab=GND}
N 4200 4160 4200 4180 {lab=FOOT}
N 4200 4130 4220 4130 {lab=GND}
N 4200 4020 4200 4040 {lab=FOOT}
N 4200 3990 4220 3990 {lab=GND}
N 4200 4440 4200 4460 {lab=FOOT}
N 4200 4410 4220 4410 {lab=GND}
N 4200 4300 4200 4320 {lab=FOOT}
N 4200 4270 4220 4270 {lab=GND}
N 4000 3600 4000 3620 {lab=FOOT}
N 4000 3570 4020 3570 {lab=GND}
N 4000 3460 4000 3480 {lab=FOOT}
N 4000 3430 4020 3430 {lab=GND}
N 4000 3880 4000 3900 {lab=FOOT}
N 4000 3850 4020 3850 {lab=GND}
N 4000 3740 4000 3760 {lab=FOOT}
N 4000 3710 4020 3710 {lab=GND}
N 4000 4160 4000 4180 {lab=FOOT}
N 4000 4130 4020 4130 {lab=GND}
N 4000 4020 4000 4040 {lab=FOOT}
N 4000 3990 4020 3990 {lab=GND}
N 4000 4440 4000 4460 {lab=FOOT}
N 4000 4410 4020 4410 {lab=GND}
N 4000 4300 4000 4320 {lab=FOOT}
N 4000 4270 4020 4270 {lab=GND}
N 3800 -1860 3800 -1840 {lab=FOOT}
N 3800 -1890 3820 -1890 {lab=GND}
N 3800 -2000 3800 -1980 {lab=FOOT}
N 3800 -2030 3820 -2030 {lab=GND}
N 3800 -1580 3800 -1560 {lab=FOOT}
N 3800 -1610 3820 -1610 {lab=GND}
N 3800 -1720 3800 -1700 {lab=FOOT}
N 3800 -1750 3820 -1750 {lab=GND}
N 3800 -1300 3800 -1280 {lab=FOOT}
N 3800 -1330 3820 -1330 {lab=GND}
N 3800 -1440 3800 -1420 {lab=FOOT}
N 3800 -1470 3820 -1470 {lab=GND}
N 3800 -1160 3800 -1140 {lab=FOOT}
N 3800 -1190 3820 -1190 {lab=GND}
N 3800 -1020 3800 -1000 {lab=FOOT}
N 3800 -1050 3820 -1050 {lab=GND}
N 3800 -740 3800 -720 {lab=FOOT}
N 3800 -770 3820 -770 {lab=GND}
N 3800 -880 3800 -860 {lab=FOOT}
N 3800 -910 3820 -910 {lab=GND}
N 3800 -460 3800 -440 {lab=FOOT}
N 3800 -490 3820 -490 {lab=GND}
N 3800 -600 3800 -580 {lab=FOOT}
N 3800 -630 3820 -630 {lab=GND}
N 3800 -180 3800 -160 {lab=FOOT}
N 3800 -210 3820 -210 {lab=GND}
N 3800 -320 3800 -300 {lab=FOOT}
N 3800 -350 3820 -350 {lab=GND}
N 3800 -40 3800 -20 {lab=FOOT}
N 3800 -70 3820 -70 {lab=GND}
N 3800 2340 3800 2360 {lab=FOOT}
N 3800 2310 3820 2310 {lab=GND}
N 3800 2620 3800 2640 {lab=FOOT}
N 3800 2590 3820 2590 {lab=GND}
N 3800 2480 3800 2500 {lab=FOOT}
N 3800 2450 3820 2450 {lab=GND}
N 3800 2900 3800 2920 {lab=FOOT}
N 3800 2870 3820 2870 {lab=GND}
N 3800 2760 3800 2780 {lab=FOOT}
N 3800 2730 3820 2730 {lab=GND}
N 3800 3180 3800 3200 {lab=FOOT}
N 3800 3150 3820 3150 {lab=GND}
N 3800 3040 3800 3060 {lab=FOOT}
N 3800 3010 3820 3010 {lab=GND}
N 3800 3320 3800 3340 {lab=FOOT}
N 3800 3290 3820 3290 {lab=GND}
N 3800 3460 3800 3480 {lab=FOOT}
N 3800 3430 3820 3430 {lab=GND}
N 3800 3740 3800 3760 {lab=FOOT}
N 3800 3710 3820 3710 {lab=GND}
N 3800 3600 3800 3620 {lab=FOOT}
N 3800 3570 3820 3570 {lab=GND}
N 3800 4020 3800 4040 {lab=FOOT}
N 3800 3990 3820 3990 {lab=GND}
N 3800 3880 3800 3900 {lab=FOOT}
N 3800 3850 3820 3850 {lab=GND}
N 3800 4300 3800 4320 {lab=FOOT}
N 3800 4270 3820 4270 {lab=GND}
N 3800 4160 3800 4180 {lab=FOOT}
N 3800 4130 3820 4130 {lab=GND}
N 3800 4440 3800 4460 {lab=FOOT}
N 3800 4410 3820 4410 {lab=GND}
N 3600 2340 3600 2360 {lab=FOOT}
N 3600 2310 3620 2310 {lab=GND}
N 3600 2620 3600 2640 {lab=FOOT}
N 3600 2590 3620 2590 {lab=GND}
N 3600 2480 3600 2500 {lab=FOOT}
N 3600 2450 3620 2450 {lab=GND}
N 3600 2900 3600 2920 {lab=FOOT}
N 3600 2870 3620 2870 {lab=GND}
N 3600 2760 3600 2780 {lab=FOOT}
N 3600 2730 3620 2730 {lab=GND}
N 3600 3180 3600 3200 {lab=FOOT}
N 3600 3150 3620 3150 {lab=GND}
N 3600 3040 3600 3060 {lab=FOOT}
N 3600 3010 3620 3010 {lab=GND}
N 3600 3320 3600 3340 {lab=FOOT}
N 3600 3290 3620 3290 {lab=GND}
N 3600 3460 3600 3480 {lab=FOOT}
N 3600 3430 3620 3430 {lab=GND}
N 3600 3740 3600 3760 {lab=FOOT}
N 3600 3710 3620 3710 {lab=GND}
N 3600 3600 3600 3620 {lab=FOOT}
N 3600 3570 3620 3570 {lab=GND}
N 3600 4020 3600 4040 {lab=FOOT}
N 3600 3990 3620 3990 {lab=GND}
N 3600 3880 3600 3900 {lab=FOOT}
N 3600 3850 3620 3850 {lab=GND}
N 3600 4300 3600 4320 {lab=FOOT}
N 3600 4270 3620 4270 {lab=GND}
N 3600 4160 3600 4180 {lab=FOOT}
N 3600 4130 3620 4130 {lab=GND}
N 3600 4440 3600 4460 {lab=FOOT}
N 3600 4410 3620 4410 {lab=GND}
N 3600 100 3600 120 {lab=FOOT}
N 3600 70 3620 70 {lab=GND}
N 3600 380 3600 400 {lab=FOOT}
N 3600 350 3620 350 {lab=GND}
N 3600 240 3600 260 {lab=FOOT}
N 3600 210 3620 210 {lab=GND}
N 3600 660 3600 680 {lab=FOOT}
N 3600 630 3620 630 {lab=GND}
N 3600 520 3600 540 {lab=FOOT}
N 3600 490 3620 490 {lab=GND}
N 3600 940 3600 960 {lab=FOOT}
N 3600 910 3620 910 {lab=GND}
N 3600 800 3600 820 {lab=FOOT}
N 3600 770 3620 770 {lab=GND}
N 3600 1080 3600 1100 {lab=FOOT}
N 3600 1050 3620 1050 {lab=GND}
N 3600 1220 3600 1240 {lab=FOOT}
N 3600 1190 3620 1190 {lab=GND}
N 3600 1500 3600 1520 {lab=FOOT}
N 3600 1470 3620 1470 {lab=GND}
N 3600 1360 3600 1380 {lab=FOOT}
N 3600 1330 3620 1330 {lab=GND}
N 3600 1780 3600 1800 {lab=FOOT}
N 3600 1750 3620 1750 {lab=GND}
N 3600 1640 3600 1660 {lab=FOOT}
N 3600 1610 3620 1610 {lab=GND}
N 3600 2060 3600 2080 {lab=FOOT}
N 3600 2030 3620 2030 {lab=GND}
N 3600 1920 3600 1940 {lab=FOOT}
N 3600 1890 3620 1890 {lab=GND}
N 3600 2200 3600 2220 {lab=FOOT}
N 3600 2170 3620 2170 {lab=GND}
N 4600 -4300 4660 -4300 {lab=B0bar}
N 4600 -4020 4660 -4020 {lab=B0bar}
N 4600 -3740 4660 -3740 {lab=B0bar}
N 4600 -3460 4660 -3460 {lab=B0bar}
N 4600 -3180 4660 -3180 {lab=B0bar}
N 4600 -2900 4660 -2900 {lab=B0bar}
N 4600 -2620 4660 -2620 {lab=B0bar}
N 4600 -2340 4660 -2340 {lab=B0bar}
N 4600 -2060 4660 -2060 {lab=B0bar}
N 4600 -1780 4660 -1780 {lab=B0bar}
N 4600 -1500 4660 -1500 {lab=B0bar}
N 4600 -1220 4660 -1220 {lab=B0bar}
N 4600 -940 4660 -940 {lab=B0bar}
N 4600 -660 4660 -660 {lab=B0bar}
N 4600 -380 4660 -380 {lab=B0bar}
N 4600 180 4660 180 {lab=B0bar}
N 4600 460 4660 460 {lab=B0bar}
N 4600 740 4660 740 {lab=B0bar}
N 4600 1020 4660 1020 {lab=B0bar}
N 4600 1300 4660 1300 {lab=B0bar}
N 4600 1580 4660 1580 {lab=B0bar}
N 4600 1860 4660 1860 {lab=B0bar}
N 4600 2140 4660 2140 {lab=B0bar}
N 4600 2420 4660 2420 {lab=B0bar}
N 4600 2700 4660 2700 {lab=B0bar}
N 4600 2980 4660 2980 {lab=B0bar}
N 4600 3260 4660 3260 {lab=B0bar}
N 4600 3540 4660 3540 {lab=B0bar}
N 4600 3820 4660 3820 {lab=B0bar}
N 4600 4100 4660 4100 {lab=B0bar}
N 4600 4380 4660 4380 {lab=B0bar}
N 4400 -4160 4460 -4160 {lab=B1bar}
N 4400 -4020 4460 -4020 {lab=B1bar}
N 4400 -3600 4460 -3600 {lab=B1bar}
N 4400 -3460 4460 -3460 {lab=B1bar}
N 4400 -3040 4460 -3040 {lab=B1bar}
N 4400 -2900 4460 -2900 {lab=B1bar}
N 4400 -2480 4460 -2480 {lab=B1bar}
N 4400 -2340 4460 -2340 {lab=B1bar}
N 4400 -1920 4460 -1920 {lab=B1bar}
N 4400 -1780 4460 -1780 {lab=B1bar}
N 4400 -1360 4460 -1360 {lab=B1bar}
N 4400 -1220 4460 -1220 {lab=B1bar}
N 4400 -800 4460 -800 {lab=B1bar}
N 4400 -660 4460 -660 {lab=B1bar}
N 4400 -240 4460 -240 {lab=B1bar}
N 4400 -100 4460 -100 {lab=B1bar}
N 4400 320 4460 320 {lab=B1bar}
N 4400 460 4460 460 {lab=B1bar}
N 4400 880 4460 880 {lab=B1bar}
N 4400 1020 4460 1020 {lab=B1bar}
N 4400 1440 4460 1440 {lab=B1bar}
N 4400 1580 4460 1580 {lab=B1bar}
N 4400 2000 4460 2000 {lab=B1bar}
N 4400 2140 4460 2140 {lab=B1bar}
N 4400 2560 4460 2560 {lab=B1bar}
N 4400 2700 4460 2700 {lab=B1bar}
N 4400 3120 4460 3120 {lab=B1bar}
N 4400 3260 4460 3260 {lab=B1bar}
N 4400 3680 4460 3680 {lab=B1bar}
N 4400 3820 4460 3820 {lab=B1bar}
N 4400 4240 4460 4240 {lab=B1bar}
N 4400 4380 4460 4380 {lab=B1bar}
N 4200 -3880 4260 -3880 {lab=B2bar}
N 4200 -3740 4260 -3740 {lab=B2bar}
N 4200 -3600 4260 -3600 {lab=B2bar}
N 4200 -3460 4260 -3460 {lab=B2bar}
N 4200 -2760 4260 -2760 {lab=B2bar}
N 4200 -2620 4260 -2620 {lab=B2bar}
N 4200 -2480 4260 -2480 {lab=B2bar}
N 4200 -2340 4260 -2340 {lab=B2bar}
N 4200 -1640 4260 -1640 {lab=B2bar}
N 4200 -1500 4260 -1500 {lab=B2bar}
N 4200 -1360 4260 -1360 {lab=B2bar}
N 4200 -1220 4260 -1220 {lab=B2bar}
N 4200 -520 4260 -520 {lab=B2bar}
N 4200 -380 4260 -380 {lab=B2bar}
N 4200 -240 4260 -240 {lab=B2bar}
N 4200 -100 4260 -100 {lab=B2bar}
N 4200 600 4260 600 {lab=B2bar}
N 4200 740 4260 740 {lab=B2bar}
N 4200 880 4260 880 {lab=B2bar}
N 4200 1020 4260 1020 {lab=B2bar}
N 4200 1720 4260 1720 {lab=B2bar}
N 4200 1860 4260 1860 {lab=B2bar}
N 4200 2000 4260 2000 {lab=B2bar}
N 4200 2140 4260 2140 {lab=B2bar}
N 4200 2840 4260 2840 {lab=B2bar}
N 4200 2980 4260 2980 {lab=B2bar}
N 4200 3120 4260 3120 {lab=B2bar}
N 4200 3260 4260 3260 {lab=B2bar}
N 4200 3960 4260 3960 {lab=B2bar}
N 4200 4100 4260 4100 {lab=B2bar}
N 4200 4240 4260 4240 {lab=B2bar}
N 4200 4380 4260 4380 {lab=B2bar}
N 4000 -3320 4060 -3320 {lab=B3bar}
N 4000 -3180 4060 -3180 {lab=B3bar}
N 4000 -3040 4060 -3040 {lab=B3bar}
N 4000 -2900 4060 -2900 {lab=B3bar}
N 4000 -2760 4060 -2760 {lab=B3bar}
N 4000 -2620 4060 -2620 {lab=B3bar}
N 4000 -2480 4060 -2480 {lab=B3bar}
N 4000 -2340 4060 -2340 {lab=B3bar}
N 4000 -1080 4060 -1080 {lab=B3bar}
N 4000 -940 4060 -940 {lab=B3bar}
N 4000 -800 4060 -800 {lab=B3bar}
N 4000 -660 4060 -660 {lab=B3bar}
N 4000 -520 4060 -520 {lab=B3bar}
N 4000 -380 4060 -380 {lab=B3bar}
N 4000 -240 4060 -240 {lab=B3bar}
N 4000 -100 4060 -100 {lab=B3bar}
N 4000 1160 4060 1160 {lab=B3bar}
N 4000 1300 4060 1300 {lab=B3bar}
N 4000 1440 4060 1440 {lab=B3bar}
N 4000 1580 4060 1580 {lab=B3bar}
N 4000 1720 4060 1720 {lab=B3bar}
N 4000 1860 4060 1860 {lab=B3bar}
N 4000 2000 4060 2000 {lab=B3bar}
N 4000 2140 4060 2140 {lab=B3bar}
N 4000 3400 4060 3400 {lab=B3bar}
N 4000 3540 4060 3540 {lab=B3bar}
N 4000 3680 4060 3680 {lab=B3bar}
N 4000 3820 4060 3820 {lab=B3bar}
N 4000 3960 4060 3960 {lab=B3bar}
N 4000 4100 4060 4100 {lab=B3bar}
N 4000 4240 4060 4240 {lab=B3bar}
N 4000 4380 4060 4380 {lab=B3bar}
N 3800 -1080 3860 -1080 {lab=B4bar}
N 3800 -940 3860 -940 {lab=B4bar}
N 3800 -800 3860 -800 {lab=B4bar}
N 3800 -660 3860 -660 {lab=B4bar}
N 3800 -520 3860 -520 {lab=B4bar}
N 3800 -380 3860 -380 {lab=B4bar}
N 3800 -240 3860 -240 {lab=B4bar}
N 3800 -100 3860 -100 {lab=B4bar}
N 3800 -2200 3860 -2200 {lab=B4bar}
N 3800 -2060 3860 -2060 {lab=B4bar}
N 3800 -1920 3860 -1920 {lab=B4bar}
N 3800 -1780 3860 -1780 {lab=B4bar}
N 3800 -1640 3860 -1640 {lab=B4bar}
N 3800 -1500 3860 -1500 {lab=B4bar}
N 3800 -1360 3860 -1360 {lab=B4bar}
N 3800 -1220 3860 -1220 {lab=B4bar}
N 3800 3400 3860 3400 {lab=B4bar}
N 3800 3540 3860 3540 {lab=B4bar}
N 3800 3680 3860 3680 {lab=B4bar}
N 3800 3820 3860 3820 {lab=B4bar}
N 3800 3960 3860 3960 {lab=B4bar}
N 3800 4100 3860 4100 {lab=B4bar}
N 3800 4240 3860 4240 {lab=B4bar}
N 3800 4380 3860 4380 {lab=B4bar}
N 3800 2280 3860 2280 {lab=B4bar}
N 3800 2420 3860 2420 {lab=B4bar}
N 3800 2560 3860 2560 {lab=B4bar}
N 3800 2700 3860 2700 {lab=B4bar}
N 3800 2840 3860 2840 {lab=B4bar}
N 3800 2980 3860 2980 {lab=B4bar}
N 3800 3120 3860 3120 {lab=B4bar}
N 3800 3260 3860 3260 {lab=B4bar}
N 3600 3400 3660 3400 {lab=B5bar}
N 3600 3540 3660 3540 {lab=B5bar}
N 3600 3680 3660 3680 {lab=B5bar}
N 3600 3820 3660 3820 {lab=B5bar}
N 3600 3960 3660 3960 {lab=B5bar}
N 3600 4100 3660 4100 {lab=B5bar}
N 3600 4240 3660 4240 {lab=B5bar}
N 3600 4380 3660 4380 {lab=B5bar}
N 3600 2280 3660 2280 {lab=B5bar}
N 3600 2420 3660 2420 {lab=B5bar}
N 3600 2560 3660 2560 {lab=B5bar}
N 3600 2700 3660 2700 {lab=B5bar}
N 3600 2840 3660 2840 {lab=B5bar}
N 3600 2980 3660 2980 {lab=B5bar}
N 3600 3120 3660 3120 {lab=B5bar}
N 3600 3260 3660 3260 {lab=B5bar}
N 3600 1160 3660 1160 {lab=B5bar}
N 3600 1300 3660 1300 {lab=B5bar}
N 3600 1440 3660 1440 {lab=B5bar}
N 3600 1580 3660 1580 {lab=B5bar}
N 3600 1720 3660 1720 {lab=B5bar}
N 3600 1860 3660 1860 {lab=B5bar}
N 3600 2000 3660 2000 {lab=B5bar}
N 3600 2140 3660 2140 {lab=B5bar}
N 3600 40 3660 40 {lab=B5bar}
N 3600 180 3660 180 {lab=B5bar}
N 3600 320 3660 320 {lab=B5bar}
N 3600 460 3660 460 {lab=B5bar}
N 3600 600 3660 600 {lab=B5bar}
N 3600 740 3660 740 {lab=B5bar}
N 3600 880 3660 880 {lab=B5bar}
N 3600 1020 3660 1020 {lab=B5bar}
N 4600 -4360 4660 -4360 {lab=B0bar}
N 4660 -4360 4660 4520 {lab=B0bar}
N 4400 -4440 4400 -4420 {lab=VDD}
N 4395 -4390 4410 -4390 {lab=VDD}
N 4400 -4360 4460 -4360 {lab=B1bar}
N 4200 -4440 4200 -4420 {lab=VDD}
N 4195 -4390 4210 -4390 {lab=VDD}
N 4200 -4360 4260 -4360 {lab=B2bar}
N 4460 -4360 4460 4520 {lab=B1bar}
N 4260 -4360 4260 4520 {lab=B2bar}
N 4060 -4360 4060 4520 {lab=B3bar}
N 3860 -4360 3860 4520 {lab=B4bar}
N 3660 -4360 3660 4520 {lab=B5bar}
N 4000 -4440 4000 -4420 {lab=VDD}
N 3995 -4390 4010 -4390 {lab=VDD}
N 4000 -4360 4060 -4360 {lab=B3bar}
N 3800 -4440 3800 -4420 {lab=VDD}
N 3795 -4390 3810 -4390 {lab=VDD}
N 3800 -4360 3860 -4360 {lab=B4bar}
N 3600 -4440 3600 -4420 {lab=VDD}
N 3595 -4390 3610 -4390 {lab=VDD}
N 3600 -4360 3660 -4360 {lab=B5bar}
N 3070 -4270 4560 -4270 {lab=IN0}
N 3070 -4130 4360 -4130 {lab=IN1}
N 4560 -4050 4560 -3990 {lab=IN2}
N 4360 -4050 4360 -3990 {lab=IN2}
N 3070 -4050 4560 -4050 {lab=IN2}
N 4160 -3910 4160 -3850 {lab=IN3}
N 4160 -3770 4160 -3710 {lab=IN4}
N 4160 -3630 4160 -3570 {lab=IN5}
N 4160 -3490 4160 -3430 {lab=IN6}
N 4160 -2790 4160 -2730 {lab=IN11}
N 4160 -2650 4160 -2590 {lab=IN12}
N 4160 -2510 4160 -2450 {lab=IN13}
N 4160 -2370 4160 -2310 {lab=IN14}
N 4160 -1670 4160 -1610 {lab=IN19}
N 4160 -1530 4160 -1470 {lab=IN20}
N 4160 -1390 4160 -1330 {lab=IN21}
N 4160 -1250 4160 -1190 {lab=IN22}
N 4160 -550 4160 -490 {lab=IN27}
N 4160 -410 4160 -350 {lab=IN28}
N 4160 -270 4160 -210 {lab=IN29}
N 4160 -130 4160 -70 {lab=IN30}
N 4160 570 4160 630 {lab=IN35}
N 4160 710 4160 770 {lab=IN36}
N 4160 850 4160 910 {lab=IN37}
N 4160 990 4160 1050 {lab=IN38}
N 4160 1690 4160 1750 {lab=IN43}
N 4160 1830 4160 1890 {lab=IN44}
N 4160 1970 4160 2030 {lab=IN45}
N 4160 2110 4160 2170 {lab=IN46}
N 4160 2810 4160 2870 {lab=IN51}
N 4160 2950 4160 3010 {lab=IN52}
N 4160 3090 4160 3150 {lab=IN53}
N 4160 3230 4160 3290 {lab=IN54}
N 4160 3930 4160 3990 {lab=IN59}
N 4160 4070 4160 4130 {lab=IN60}
N 4160 4210 4160 4270 {lab=IN61}
N 4160 4350 4160 4410 {lab=IN62}
N 3960 3930 3960 3990 {lab=IN59}
N 3960 4070 3960 4130 {lab=IN60}
N 3960 4210 3960 4270 {lab=IN61}
N 3960 4350 3960 4410 {lab=IN62}
N 3960 3370 3960 3430 {lab=IN55}
N 3960 3510 3960 3570 {lab=IN56}
N 3960 3650 3960 3710 {lab=IN57}
N 3960 3790 3960 3850 {lab=IN58}
N 3960 1690 3960 1750 {lab=IN43}
N 3960 1830 3960 1890 {lab=IN44}
N 3960 1970 3960 2030 {lab=IN45}
N 3960 2110 3960 2170 {lab=IN46}
N 3960 1130 3960 1190 {lab=IN39}
N 3960 1270 3960 1330 {lab=IN40}
N 3960 1410 3960 1470 {lab=IN41}
N 3960 1550 3960 1610 {lab=IN42}
N 4560 -3770 4560 -3710 {lab=IN4}
N 4560 -3490 4560 -3430 {lab=IN6}
N 4560 -3210 4560 -3150 {lab=IN8}
N 4560 -2930 4560 -2870 {lab=IN10}
N 4560 -2650 4560 -2590 {lab=IN12}
N 4560 -2370 4560 -2310 {lab=IN14}
N 4560 -2090 4560 -2030 {lab=IN16}
N 4560 -1810 4560 -1750 {lab=IN18}
N 4560 -1530 4560 -1470 {lab=IN20}
N 4560 -1250 4560 -1190 {lab=IN22}
N 4560 -970 4560 -910 {lab=IN24}
N 4560 -690 4560 -630 {lab=IN26}
N 4560 -410 4560 -350 {lab=IN28}
N 4560 -130 4560 -70 {lab=IN30}
N 4560 150 4560 210 {lab=IN32}
N 4560 430 4560 490 {lab=IN34}
N 4560 710 4560 770 {lab=IN36}
N 4560 990 4560 1050 {lab=IN38}
N 4560 1270 4560 1330 {lab=IN40}
N 4560 1550 4560 1610 {lab=IN42}
N 4560 1830 4560 1890 {lab=IN44}
N 4560 2110 4560 2170 {lab=IN46}
N 4560 2390 4560 2450 {lab=IN48}
N 4560 2670 4560 2730 {lab=IN50}
N 4560 2950 4560 3010 {lab=IN52}
N 4560 3230 4560 3290 {lab=IN54}
N 4560 3510 4560 3570 {lab=IN56}
N 4560 3790 4560 3850 {lab=IN58}
N 4560 4070 4560 4130 {lab=IN60}
N 4560 4350 4560 4410 {lab=IN62}
N 3960 -550 3960 -490 {lab=IN27}
N 3960 -410 3960 -350 {lab=IN28}
N 3960 -270 3960 -210 {lab=IN29}
N 3960 -130 3960 -70 {lab=IN30}
N 3960 -1110 3960 -1050 {lab=IN23}
N 3960 -970 3960 -910 {lab=IN24}
N 3960 -830 3960 -770 {lab=IN25}
N 3960 -690 3960 -630 {lab=IN26}
N 3960 -2790 3960 -2730 {lab=IN11}
N 3960 -2650 3960 -2590 {lab=IN12}
N 3960 -2510 3960 -2450 {lab=IN13}
N 3960 -2370 3960 -2310 {lab=IN14}
N 3960 -3350 3960 -3290 {lab=IN7}
N 3960 -3210 3960 -3150 {lab=IN8}
N 3960 -3070 3960 -3010 {lab=IN9}
N 3960 -2930 3960 -2870 {lab=IN10}
N 3760 -1670 3760 -1610 {lab=IN19}
N 3760 -1530 3760 -1470 {lab=IN20}
N 3760 -1390 3760 -1330 {lab=IN21}
N 3760 -1250 3760 -1190 {lab=IN22}
N 3760 -2230 3760 -2170 {lab=IN15}
N 3760 -2090 3760 -2030 {lab=IN16}
N 3760 -1950 3760 -1890 {lab=IN17}
N 3760 -1810 3760 -1750 {lab=IN18}
N 3760 -550 3760 -490 {lab=IN27}
N 3760 -410 3760 -350 {lab=IN28}
N 3760 -270 3760 -210 {lab=IN29}
N 3760 -130 3760 -70 {lab=IN30}
N 3760 -1110 3760 -1050 {lab=IN23}
N 3760 -970 3760 -910 {lab=IN24}
N 3760 -830 3760 -770 {lab=IN25}
N 3760 -690 3760 -630 {lab=IN26}
N 3560 570 3560 630 {lab=IN35}
N 3560 710 3560 770 {lab=IN36}
N 3560 850 3560 910 {lab=IN37}
N 3560 990 3560 1050 {lab=IN38}
N 3560 10 3560 70 {lab=IN31}
N 3560 150 3560 210 {lab=IN32}
N 3560 290 3560 350 {lab=IN33}
N 3560 430 3560 490 {lab=IN34}
N 3560 1690 3560 1750 {lab=IN43}
N 3560 1830 3560 1890 {lab=IN44}
N 3560 1970 3560 2030 {lab=IN45}
N 3560 2110 3560 2170 {lab=IN46}
N 3560 1130 3560 1190 {lab=IN39}
N 3560 1270 3560 1330 {lab=IN40}
N 3560 1410 3560 1470 {lab=IN41}
N 3560 1550 3560 1610 {lab=IN42}
N 3560 2810 3560 2870 {lab=IN51}
N 3560 2950 3560 3010 {lab=IN52}
N 3560 3090 3560 3150 {lab=IN53}
N 3560 3230 3560 3290 {lab=IN54}
N 3560 2250 3560 2310 {lab=IN47}
N 3560 2390 3560 2450 {lab=IN48}
N 3560 2530 3560 2590 {lab=IN49}
N 3560 2670 3560 2730 {lab=IN50}
N 3560 3930 3560 3990 {lab=IN59}
N 3560 4070 3560 4130 {lab=IN60}
N 3560 4210 3560 4270 {lab=IN61}
N 3560 4350 3560 4410 {lab=IN62}
N 3560 3370 3560 3430 {lab=IN55}
N 3560 3510 3560 3570 {lab=IN56}
N 3560 3650 3560 3710 {lab=IN57}
N 3560 3790 3560 3850 {lab=IN58}
N 3760 2810 3760 2870 {lab=IN51}
N 3760 2950 3760 3010 {lab=IN52}
N 3760 3090 3760 3150 {lab=IN53}
N 3760 3230 3760 3290 {lab=IN54}
N 3760 2250 3760 2310 {lab=IN47}
N 3760 2390 3760 2450 {lab=IN48}
N 3760 2530 3760 2590 {lab=IN49}
N 3760 2670 3760 2730 {lab=IN50}
N 3760 3930 3760 3990 {lab=IN59}
N 3760 4070 3760 4130 {lab=IN60}
N 3760 4210 3760 4270 {lab=IN61}
N 3760 4350 3760 4410 {lab=IN62}
N 3760 3370 3760 3430 {lab=IN55}
N 3760 3510 3760 3570 {lab=IN56}
N 3760 3650 3760 3710 {lab=IN57}
N 3760 3790 3760 3850 {lab=IN58}
N 4360 1970 4360 2030 {lab=IN45}
N 4360 2110 4360 2170 {lab=IN46}
N 4360 1410 4360 1470 {lab=IN41}
N 4360 1550 4360 1610 {lab=IN42}
N 4360 850 4360 910 {lab=IN37}
N 4360 990 4360 1050 {lab=IN38}
N 4360 -270 4360 -210 {lab=IN29}
N 4360 -130 4360 -70 {lab=IN30}
N 4360 -830 4360 -770 {lab=IN25}
N 4360 -690 4360 -630 {lab=IN26}
N 4360 -1390 4360 -1330 {lab=IN21}
N 4360 -1250 4360 -1190 {lab=IN22}
N 4360 -1950 4360 -1890 {lab=IN17}
N 4360 -1810 4360 -1750 {lab=IN18}
N 4360 -2510 4360 -2450 {lab=IN13}
N 4360 -2370 4360 -2310 {lab=IN14}
N 4360 -3070 4360 -3010 {lab=IN9}
N 4360 -2930 4360 -2870 {lab=IN10}
N 4360 4210 4360 4270 {lab=IN61}
N 4360 4350 4360 4410 {lab=IN62}
N 4360 3650 4360 3710 {lab=IN57}
N 4360 3790 4360 3850 {lab=IN58}
N 4360 3090 4360 3150 {lab=IN53}
N 4360 3230 4360 3290 {lab=IN54}
N 4360 2530 4360 2590 {lab=IN49}
N 4360 2670 4360 2730 {lab=IN50}
N 4360 290 4360 350 {lab=IN33}
N 4360 430 4360 490 {lab=IN34}
N 4360 -3630 4360 -3570 {lab=IN5}
N 4360 -3490 4360 -3430 {lab=IN6}
N 3060 -3910 4550 -3910 {lab=IN3}
N 3070 -3770 4560 -3770 {lab=IN4}
N 3070 -3630 4560 -3630 {lab=IN5}
N 3070 -3490 4560 -3490 {lab=IN6}
N 3080 -3350 4570 -3350 {lab=IN7}
N 3080 -3210 4570 -3210 {lab=IN8}
N 3070 -3070 4560 -3070 {lab=IN9}
N 3080 -2930 4570 -2930 {lab=IN10}
N 3080 -2790 4570 -2790 {lab=IN11}
N 3070 -2650 4560 -2650 {lab=IN12}
N 3080 -2510 4570 -2510 {lab=IN13}
N 3080 -2370 4570 -2370 {lab=IN14}
N 3060 -2230 4550 -2230 {lab=IN15}
N 3070 -2090 4560 -2090 {lab=IN16}
N 3070 -1950 4560 -1950 {lab=IN17}
N 3070 -1810 4560 -1810 {lab=IN18}
N 3080 -1670 4570 -1670 {lab=IN19}
N 3080 -1530 4570 -1530 {lab=IN20}
N 3060 -1390 4550 -1390 {lab=IN21}
N 3070 -1250 4560 -1250 {lab=IN22}
N 3070 -1110 4560 -1110 {lab=IN23}
N 3070 -970 4560 -970 {lab=IN24}
N 3070 -830 4560 -830 {lab=IN25}
N 3080 -690 4570 -690 {lab=IN26}
N 3080 -550 4570 -550 {lab=IN27}
N 3070 -410 4560 -410 {lab=IN28}
N 3080 -270 4570 -270 {lab=IN29}
N 3080 -130 4570 -130 {lab=IN30}
N 3070 10 4560 10 {lab=IN31}
N 3080 150 4570 150 {lab=IN32}
N 3080 290 4570 290 {lab=IN33}
N 3060 430 4550 430 {lab=IN34}
N 3070 570 4560 570 {lab=IN35}
N 3070 710 4560 710 {lab=IN36}
N 3070 850 4560 850 {lab=IN37}
N 3080 990 4570 990 {lab=IN38}
N 3080 1130 4570 1130 {lab=IN39}
N 3060 1270 4550 1270 {lab=IN40}
N 3070 1410 4560 1410 {lab=IN41}
N 3070 1550 4560 1550 {lab=IN42}
N 3070 1690 4560 1690 {lab=IN43}
N 3070 1830 4560 1830 {lab=IN44}
N 3080 1970 4570 1970 {lab=IN45}
N 3080 2110 4570 2110 {lab=IN46}
N 3070 2250 4560 2250 {lab=IN47}
N 3080 2390 4570 2390 {lab=IN48}
N 3080 2530 4570 2530 {lab=IN49}
N 3070 2670 4560 2670 {lab=IN50}
N 3080 2810 4570 2810 {lab=IN51}
N 3080 2950 4570 2950 {lab=IN52}
N 3060 3090 4550 3090 {lab=IN53}
N 3070 3230 4560 3230 {lab=IN54}
N 3070 3370 4560 3370 {lab=IN55}
N 3070 3510 4560 3510 {lab=IN56}
N 3080 3650 4570 3650 {lab=IN57}
N 3080 3790 4570 3790 {lab=IN58}
N 3060 3930 4550 3930 {lab=IN59}
N 3070 4070 4560 4070 {lab=IN60}
N 3070 4210 4560 4210 {lab=IN61}
N 3070 4350 4560 4350 {lab=IN62}
N 3620 5325 3620 5345 {lab=GND}
N 3620 5295 3640 5295 {lab=GND}
N 3620 5265 3650 5265 {lab=FOOT}
N 3640 5295 3640 5345 {lab=GND}
N 3620 5345 3640 5345 {lab=GND}
N 3620 5345 3620 5365 {lab=GND}
N 3550 5295 3580 5295 {lab=CLK_EVAL}
N 3820 5325 3820 5345 {lab=GND}
N 3820 5295 3840 5295 {lab=GND}
N 3820 5265 3850 5265 {lab=FOOT}
N 3840 5295 3840 5345 {lab=GND}
N 3820 5345 3840 5345 {lab=GND}
N 3820 5345 3820 5365 {lab=GND}
N 3750 5295 3780 5295 {lab=CLK_EVAL}
N 4020 5325 4020 5345 {lab=GND}
N 4020 5295 4040 5295 {lab=GND}
N 4020 5265 4050 5265 {lab=FOOT}
N 4040 5295 4040 5345 {lab=GND}
N 4020 5345 4040 5345 {lab=GND}
N 4020 5345 4020 5365 {lab=GND}
N 3950 5295 3980 5295 {lab=CLK_EVAL}
N 4220 5325 4220 5345 {lab=GND}
N 4220 5295 4240 5295 {lab=GND}
N 4220 5265 4250 5265 {lab=FOOT}
N 4240 5295 4240 5345 {lab=GND}
N 4220 5345 4240 5345 {lab=GND}
N 4220 5345 4220 5365 {lab=GND}
N 4150 5295 4180 5295 {lab=CLK_EVAL}
N 4420 5325 4420 5345 {lab=GND}
N 4420 5295 4440 5295 {lab=GND}
N 4420 5265 4450 5265 {lab=FOOT}
N 4440 5295 4440 5345 {lab=GND}
N 4420 5345 4440 5345 {lab=GND}
N 4420 5345 4420 5365 {lab=GND}
N 4350 5295 4380 5295 {lab=CLK_EVAL}
N 4620 5325 4620 5345 {lab=GND}
N 4620 5295 4640 5295 {lab=GND}
N 4620 5265 4650 5265 {lab=FOOT}
N 4640 5295 4640 5345 {lab=GND}
N 4620 5345 4640 5345 {lab=GND}
N 4620 5345 4620 5365 {lab=GND}
N 4550 5295 4580 5295 {lab=CLK_EVAL}
N 4520 -4390 4560 -4390 {lab=CLK_PRE}
N 4320 -4390 4360 -4390 {lab=CLK_PRE}
N 4120 -4390 4160 -4390 {lab=CLK_PRE}
N 3920 -4390 3960 -4390 {lab=CLK_PRE}
N 3720 -4390 3760 -4390 {lab=CLK_PRE}
N 3520 -4390 3560 -4390 {lab=CLK_PRE}
N 4600 -100 4660 -100 {lab=B0bar}
N 4550 430 4560 430 {lab=IN34}
N 4550 1270 4560 1270 {lab=IN40}
N 3300 4650 3300 4730 {lab=B5bar}
N 3300 4650 3370 4650 {lab=B5bar}
N 3300 4730 3300 4800 {lab=B5bar}
N 3300 4800 3370 4800 {lab=B5bar}
N 3410 4680 3410 4770 {lab=B5out}
N 3410 4730 3520 4730 {lab=B5out}
N 3410 4830 3410 4850 {lab=GND}
N 3410 4600 3410 4620 {lab=VDD}
N 3260 4730 3300 4730 {lab=B5bar}
N 3405 4650 3420 4650 {lab=VDD}
N 3410 4800 3430 4800 {lab=GND}
N 3610 4650 3610 4730 {lab=B4bar}
N 3610 4650 3680 4650 {lab=B4bar}
N 3610 4730 3610 4800 {lab=B4bar}
N 3610 4800 3680 4800 {lab=B4bar}
N 3720 4680 3720 4770 {lab=B4out}
N 3720 4730 3830 4730 {lab=B4out}
N 3720 4830 3720 4850 {lab=GND}
N 3720 4600 3720 4620 {lab=VDD}
N 3570 4730 3610 4730 {lab=B4bar}
N 3715 4650 3730 4650 {lab=VDD}
N 3720 4800 3740 4800 {lab=GND}
N 3920 4650 3920 4730 {lab=B3bar}
N 3920 4650 3990 4650 {lab=B3bar}
N 3920 4730 3920 4800 {lab=B3bar}
N 3920 4800 3990 4800 {lab=B3bar}
N 4030 4680 4030 4770 {lab=B3out}
N 4030 4730 4140 4730 {lab=B3out}
N 4030 4830 4030 4850 {lab=GND}
N 4030 4600 4030 4620 {lab=VDD}
N 3880 4730 3920 4730 {lab=B3bar}
N 4025 4650 4040 4650 {lab=VDD}
N 4030 4800 4050 4800 {lab=GND}
N 4240 4650 4240 4730 {lab=B2bar}
N 4240 4650 4310 4650 {lab=B2bar}
N 4240 4730 4240 4800 {lab=B2bar}
N 4240 4800 4310 4800 {lab=B2bar}
N 4350 4680 4350 4770 {lab=B2out}
N 4350 4730 4460 4730 {lab=B2out}
N 4350 4830 4350 4850 {lab=GND}
N 4350 4600 4350 4620 {lab=VDD}
N 4200 4730 4240 4730 {lab=B2bar}
N 4345 4650 4360 4650 {lab=VDD}
N 4350 4800 4370 4800 {lab=GND}
N 4560 4650 4560 4730 {lab=B1bar}
N 4560 4650 4630 4650 {lab=B1bar}
N 4560 4730 4560 4800 {lab=B1bar}
N 4560 4800 4630 4800 {lab=B1bar}
N 4670 4680 4670 4770 {lab=B1out}
N 4670 4730 4780 4730 {lab=B1out}
N 4670 4830 4670 4850 {lab=GND}
N 4670 4600 4670 4620 {lab=VDD}
N 4520 4730 4560 4730 {lab=B1bar}
N 4665 4650 4680 4650 {lab=VDD}
N 4670 4800 4690 4800 {lab=GND}
N 4880 4650 4880 4730 {lab=B0bar}
N 4880 4650 4950 4650 {lab=B0bar}
N 4880 4730 4880 4800 {lab=B0bar}
N 4880 4800 4950 4800 {lab=B0bar}
N 4990 4680 4990 4770 {lab=B0out}
N 4990 4730 5100 4730 {lab=B0out}
N 4990 4830 4990 4850 {lab=GND}
N 4990 4600 4990 4620 {lab=VDD}
N 4840 4730 4880 4730 {lab=B0bar}
N 4985 4650 5000 4650 {lab=VDD}
N 4990 4800 5010 4800 {lab=GND}
N 2880 -1780 2880 -1750 {lab=VDD}
N 2880 -1690 2880 -1670 {lab=GND}
N 3285 4965 3335 4965 {lab=B5}
N 2935 4965 2985 4965 {lab=VDD}
N 2935 4985 2985 4985 {lab=RST}
N 2935 5045 2985 5045 {lab=GND}
N 2965 5005 2985 5005 {lab=CLK_EVAL}
N 2970 5025 2985 5025 {lab=B5out}
N 3835 4980 3885 4980 {lab=B4}
N 3485 4980 3535 4980 {lab=VDD}
N 3485 5000 3535 5000 {lab=RST}
N 3485 5060 3535 5060 {lab=GND}
N 3515 5020 3535 5020 {lab=CLK_EVAL}
N 3520 5040 3535 5040 {lab=B4out}
N 4340 4985 4390 4985 {lab=B3}
N 3990 4985 4040 4985 {lab=VDD}
N 3990 5005 4040 5005 {lab=RST}
N 3990 5065 4040 5065 {lab=GND}
N 4020 5025 4040 5025 {lab=CLK_EVAL}
N 4025 5045 4040 5045 {lab=B3out}
N 4840 4995 4890 4995 {lab=B2}
N 4490 4995 4540 4995 {lab=VDD}
N 4490 5015 4540 5015 {lab=RST}
N 4490 5075 4540 5075 {lab=GND}
N 4520 5035 4540 5035 {lab=CLK_EVAL}
N 4525 5055 4540 5055 {lab=B2out}
N 5345 5000 5395 5000 {lab=B1}
N 4995 5000 5045 5000 {lab=VDD}
N 4995 5020 5045 5020 {lab=RST}
N 4995 5080 5045 5080 {lab=GND}
N 5025 5040 5045 5040 {lab=CLK_EVAL}
N 5030 5060 5045 5060 {lab=B1out}
N 5840 5005 5890 5005 {lab=B0}
N 5490 5005 5540 5005 {lab=VDD}
N 5490 5025 5540 5025 {lab=RST}
N 5490 5085 5540 5085 {lab=GND}
N 5520 5045 5540 5045 {lab=CLK_EVAL}
N 5525 5065 5540 5065 {lab=B0out}
C {lab_wire.sym} 4600 -4440 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 4580 -4390 0 0 {name=M5
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4605 -4390 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4600 -4230 0 0 {name=p7 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -4270 0 0 {name=M6
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -4270 0 0 {name=p23 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -3950 0 0 {name=p141 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -3990 0 0 {name=M71
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -3990 0 0 {name=p142 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -3670 0 0 {name=p149 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -3710 0 0 {name=M75
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -3710 0 0 {name=p150 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -3950 0 0 {name=p153 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -3990 0 0 {name=M77
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -3990 0 0 {name=p154 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -4090 0 0 {name=p155 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -4130 0 0 {name=M78
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -4130 0 0 {name=p156 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -3530 0 0 {name=p159 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -3570 0 0 {name=M80
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -3570 0 0 {name=p160 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -3390 0 0 {name=p163 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -3430 0 0 {name=M82
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -3430 0 0 {name=p164 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -3390 0 0 {name=p165 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -3430 0 0 {name=M83
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -3430 0 0 {name=p166 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -3670 0 0 {name=p143 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -3710 0 0 {name=M72
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -3710 0 0 {name=p144 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -3810 0 0 {name=p145 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -3850 0 0 {name=M73
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -3850 0 0 {name=p146 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -3390 0 0 {name=p147 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -3430 0 0 {name=M74
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -3430 0 0 {name=p148 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -3530 0 0 {name=p151 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -3570 0 0 {name=M76
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -3570 0 0 {name=p152 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -3110 0 0 {name=p161 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -3150 0 0 {name=M81
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -3150 0 0 {name=p162 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -2830 0 0 {name=p167 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -2870 0 0 {name=M84
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -2870 0 0 {name=p168 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -2550 0 0 {name=p169 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -2590 0 0 {name=M85
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -2590 0 0 {name=p170 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -2830 0 0 {name=p171 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -2870 0 0 {name=M86
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -2870 0 0 {name=p172 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -2970 0 0 {name=p173 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -3010 0 0 {name=M87
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -3010 0 0 {name=p174 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -2410 0 0 {name=p175 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -2450 0 0 {name=M88
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -2450 0 0 {name=p176 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -2270 0 0 {name=p177 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -2310 0 0 {name=M89
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -2310 0 0 {name=p178 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -2270 0 0 {name=p179 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -2310 0 0 {name=M90
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -2310 0 0 {name=p180 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -2550 0 0 {name=p181 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -2590 0 0 {name=M91
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -2590 0 0 {name=p182 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -2690 0 0 {name=p183 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -2730 0 0 {name=M92
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -2730 0 0 {name=p184 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -2270 0 0 {name=p185 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -2310 0 0 {name=M93
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -2310 0 0 {name=p186 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -2410 0 0 {name=p187 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -2450 0 0 {name=M94
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -2450 0 0 {name=p188 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -3110 0 0 {name=p157 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -3150 0 0 {name=M79
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -3150 0 0 {name=p158 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -3250 0 0 {name=p189 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -3290 0 0 {name=M95
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -3290 0 0 {name=p190 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -2830 0 0 {name=p191 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -2870 0 0 {name=M96
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -2870 0 0 {name=p192 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -2970 0 0 {name=p193 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -3010 0 0 {name=M97
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -3010 0 0 {name=p194 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -2550 0 0 {name=p195 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -2590 0 0 {name=M98
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -2590 0 0 {name=p196 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -2690 0 0 {name=p197 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -2730 0 0 {name=M99
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -2730 0 0 {name=p198 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -2270 0 0 {name=p199 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -2310 0 0 {name=M100
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -2310 0 0 {name=p200 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -2410 0 0 {name=p201 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -2450 0 0 {name=M101
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -2450 0 0 {name=p202 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -2130 0 0 {name=p203 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -2170 0 0 {name=M102
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -2170 0 0 {name=p204 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -1990 0 0 {name=p205 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -2030 0 0 {name=M103
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -2030 0 0 {name=p206 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -1710 0 0 {name=p207 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -1750 0 0 {name=M104
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -1750 0 0 {name=p208 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -1430 0 0 {name=p209 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -1470 0 0 {name=M105
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -1470 0 0 {name=p210 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -1710 0 0 {name=p211 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -1750 0 0 {name=M106
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -1750 0 0 {name=p212 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -1850 0 0 {name=p213 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -1890 0 0 {name=M107
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -1890 0 0 {name=p214 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -1290 0 0 {name=p215 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -1330 0 0 {name=M108
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -1330 0 0 {name=p216 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -1150 0 0 {name=p217 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -1190 0 0 {name=M109
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -1190 0 0 {name=p218 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -1150 0 0 {name=p219 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -1190 0 0 {name=M110
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -1190 0 0 {name=p220 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -1430 0 0 {name=p221 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -1470 0 0 {name=M111
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -1470 0 0 {name=p222 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -1570 0 0 {name=p223 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -1610 0 0 {name=M112
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -1610 0 0 {name=p224 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -1150 0 0 {name=p225 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -1190 0 0 {name=M113
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -1190 0 0 {name=p226 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -1290 0 0 {name=p227 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -1330 0 0 {name=M114
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -1330 0 0 {name=p228 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -870 0 0 {name=p229 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -910 0 0 {name=M115
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -910 0 0 {name=p230 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -590 0 0 {name=p231 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -630 0 0 {name=M116
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -630 0 0 {name=p232 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -310 0 0 {name=p233 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -350 0 0 {name=M117
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -350 0 0 {name=p234 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -590 0 0 {name=p235 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -630 0 0 {name=M118
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -630 0 0 {name=p236 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -730 0 0 {name=p237 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -770 0 0 {name=M119
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -770 0 0 {name=p238 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -170 0 0 {name=p239 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -210 0 0 {name=M120
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -210 0 0 {name=p240 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 -30 0 0 {name=p241 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 -70 0 0 {name=M121
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 -70 0 0 {name=p242 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -30 0 0 {name=p243 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 -70 0 0 {name=M122
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 -70 0 0 {name=p244 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -310 0 0 {name=p245 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -350 0 0 {name=M123
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -350 0 0 {name=p246 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -450 0 0 {name=p247 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -490 0 0 {name=M124
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -490 0 0 {name=p248 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -30 0 0 {name=p249 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -70 0 0 {name=M125
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -70 0 0 {name=p250 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 -170 0 0 {name=p251 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 -210 0 0 {name=M126
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 -210 0 0 {name=p252 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -870 0 0 {name=p253 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -910 0 0 {name=M127
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -910 0 0 {name=p254 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -1010 0 0 {name=p255 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -1050 0 0 {name=M128
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -1050 0 0 {name=p256 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -590 0 0 {name=p257 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -630 0 0 {name=M129
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -630 0 0 {name=p258 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -730 0 0 {name=p259 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -770 0 0 {name=M130
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -770 0 0 {name=p260 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -310 0 0 {name=p261 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -350 0 0 {name=M131
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -350 0 0 {name=p262 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -450 0 0 {name=p263 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -490 0 0 {name=M132
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -490 0 0 {name=p264 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -30 0 0 {name=p265 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -70 0 0 {name=M133
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -70 0 0 {name=p266 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 -170 0 0 {name=p267 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 -210 0 0 {name=M134
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 -210 0 0 {name=p268 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 250 0 0 {name=p271 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 210 0 0 {name=M136
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 210 0 0 {name=p272 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 530 0 0 {name=p273 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 490 0 0 {name=M137
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 490 0 0 {name=p274 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 810 0 0 {name=p275 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 770 0 0 {name=M138
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 770 0 0 {name=p276 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 530 0 0 {name=p277 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 490 0 0 {name=M139
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 490 0 0 {name=p278 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 390 0 0 {name=p279 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 350 0 0 {name=M140
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 350 0 0 {name=p280 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 950 0 0 {name=p281 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 910 0 0 {name=M141
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 910 0 0 {name=p282 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 1090 0 0 {name=p283 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 1050 0 0 {name=M142
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 1050 0 0 {name=p284 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 1090 0 0 {name=p285 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 1050 0 0 {name=M143
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 1050 0 0 {name=p286 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 810 0 0 {name=p287 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 770 0 0 {name=M144
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 770 0 0 {name=p288 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 670 0 0 {name=p289 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 630 0 0 {name=M145
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 630 0 0 {name=p290 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 1090 0 0 {name=p291 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 1050 0 0 {name=M146
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 1050 0 0 {name=p292 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 950 0 0 {name=p293 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 910 0 0 {name=M147
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 910 0 0 {name=p294 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 1370 0 0 {name=p295 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 1330 0 0 {name=M148
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 1330 0 0 {name=p296 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 1650 0 0 {name=p297 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 1610 0 0 {name=M149
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 1610 0 0 {name=p298 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 1930 0 0 {name=p299 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 1890 0 0 {name=M150
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 1890 0 0 {name=p300 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 1650 0 0 {name=p301 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 1610 0 0 {name=M151
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 1610 0 0 {name=p302 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 1510 0 0 {name=p303 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 1470 0 0 {name=M152
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 1470 0 0 {name=p304 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 2070 0 0 {name=p305 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 2030 0 0 {name=M153
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 2030 0 0 {name=p306 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 2210 0 0 {name=p307 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 2170 0 0 {name=M154
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 2170 0 0 {name=p308 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 2210 0 0 {name=p309 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 2170 0 0 {name=M155
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 2170 0 0 {name=p310 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 1930 0 0 {name=p311 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 1890 0 0 {name=M156
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 1890 0 0 {name=p312 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 1790 0 0 {name=p313 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 1750 0 0 {name=M157
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 1750 0 0 {name=p314 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 2210 0 0 {name=p315 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 2170 0 0 {name=M158
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 2170 0 0 {name=p316 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 2070 0 0 {name=p317 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 2030 0 0 {name=M159
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 2030 0 0 {name=p318 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 1370 0 0 {name=p319 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 1330 0 0 {name=M160
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 1330 0 0 {name=p320 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 1230 0 0 {name=p321 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 1190 0 0 {name=M161
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 1190 0 0 {name=p322 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 1650 0 0 {name=p323 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 1610 0 0 {name=M162
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 1610 0 0 {name=p324 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 1510 0 0 {name=p325 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 1470 0 0 {name=M163
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 1470 0 0 {name=p326 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 1930 0 0 {name=p327 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 1890 0 0 {name=M164
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 1890 0 0 {name=p328 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 1790 0 0 {name=p329 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 1750 0 0 {name=M165
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 1750 0 0 {name=p330 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 2210 0 0 {name=p331 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 2170 0 0 {name=M166
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 2170 0 0 {name=p332 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 2070 0 0 {name=p333 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 2030 0 0 {name=M167
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 2030 0 0 {name=p334 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 2490 0 0 {name=p337 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 2450 0 0 {name=M169
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 2450 0 0 {name=p338 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 2770 0 0 {name=p339 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 2730 0 0 {name=M170
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 2730 0 0 {name=p340 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 3050 0 0 {name=p341 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 3010 0 0 {name=M171
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 3010 0 0 {name=p342 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 2770 0 0 {name=p343 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 2730 0 0 {name=M172
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 2730 0 0 {name=p344 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 2630 0 0 {name=p345 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 2590 0 0 {name=M173
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 2590 0 0 {name=p346 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 3190 0 0 {name=p347 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 3150 0 0 {name=M174
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 3150 0 0 {name=p348 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 3330 0 0 {name=p349 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 3290 0 0 {name=M175
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 3290 0 0 {name=p350 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 3330 0 0 {name=p351 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 3290 0 0 {name=M176
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 3290 0 0 {name=p352 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 3050 0 0 {name=p353 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 3010 0 0 {name=M177
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 3010 0 0 {name=p354 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 2910 0 0 {name=p355 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 2870 0 0 {name=M178
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 2870 0 0 {name=p356 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 3330 0 0 {name=p357 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 3290 0 0 {name=M179
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 3290 0 0 {name=p358 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 3190 0 0 {name=p359 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 3150 0 0 {name=M180
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 3150 0 0 {name=p360 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 3610 0 0 {name=p361 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 3570 0 0 {name=M181
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 3570 0 0 {name=p362 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 3890 0 0 {name=p363 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 3850 0 0 {name=M182
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 3850 0 0 {name=p364 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 4170 0 0 {name=p365 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 4130 0 0 {name=M183
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 4130 0 0 {name=p366 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 3890 0 0 {name=p367 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 3850 0 0 {name=M184
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 3850 0 0 {name=p368 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 3750 0 0 {name=p369 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 3710 0 0 {name=M185
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 3710 0 0 {name=p370 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 4310 0 0 {name=p371 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 4270 0 0 {name=M186
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 4270 0 0 {name=p372 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4600 4450 0 0 {name=p373 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4580 4410 0 0 {name=M187
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4615 4410 0 0 {name=p374 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 4450 0 0 {name=p375 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4380 4410 0 0 {name=M188
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4415 4410 0 0 {name=p376 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 4170 0 0 {name=p377 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 4130 0 0 {name=M189
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 4130 0 0 {name=p378 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 4030 0 0 {name=p379 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 3990 0 0 {name=M190
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 3990 0 0 {name=p380 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 4450 0 0 {name=p381 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 4410 0 0 {name=M191
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 4410 0 0 {name=p382 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4200 4310 0 0 {name=p383 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4180 4270 0 0 {name=M192
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4215 4270 0 0 {name=p384 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 3610 0 0 {name=p385 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 3570 0 0 {name=M193
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 3570 0 0 {name=p386 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 3470 0 0 {name=p387 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 3430 0 0 {name=M194
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 3430 0 0 {name=p388 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 3890 0 0 {name=p389 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 3850 0 0 {name=M195
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 3850 0 0 {name=p390 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 3750 0 0 {name=p391 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 3710 0 0 {name=M196
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 3710 0 0 {name=p392 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 4170 0 0 {name=p393 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 4130 0 0 {name=M197
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 4130 0 0 {name=p394 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 4030 0 0 {name=p395 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 3990 0 0 {name=M198
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 3990 0 0 {name=p396 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 4450 0 0 {name=p397 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 4410 0 0 {name=M199
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 4410 0 0 {name=p398 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4000 4310 0 0 {name=p399 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3980 4270 0 0 {name=M200
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4015 4270 0 0 {name=p400 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -1850 0 0 {name=p1 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -1890 0 0 {name=M1
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -1890 0 0 {name=p2 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -1990 0 0 {name=p3 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -2030 0 0 {name=M2
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -2030 0 0 {name=p4 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -1570 0 0 {name=p6 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -1610 0 0 {name=M3
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -1610 0 0 {name=p8 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -1710 0 0 {name=p9 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -1750 0 0 {name=M4
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -1750 0 0 {name=p10 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -1290 0 0 {name=p11 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -1330 0 0 {name=M7
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -1330 0 0 {name=p12 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -1430 0 0 {name=p13 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -1470 0 0 {name=M8
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -1470 0 0 {name=p14 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -1150 0 0 {name=p18 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -1190 0 0 {name=M10
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -1190 0 0 {name=p19 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -1010 0 0 {name=p15 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -1050 0 0 {name=M9
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -1050 0 0 {name=p16 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -730 0 0 {name=p20 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -770 0 0 {name=M11
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -770 0 0 {name=p21 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -870 0 0 {name=p22 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -910 0 0 {name=M12
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -910 0 0 {name=p24 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -450 0 0 {name=p25 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -490 0 0 {name=M13
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -490 0 0 {name=p26 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -590 0 0 {name=p27 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -630 0 0 {name=M14
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -630 0 0 {name=p28 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -170 0 0 {name=p29 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -210 0 0 {name=M15
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -210 0 0 {name=p30 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -310 0 0 {name=p31 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -350 0 0 {name=M16
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -350 0 0 {name=p32 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 -30 0 0 {name=p33 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 -70 0 0 {name=M17
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 -70 0 0 {name=p34 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 2350 0 0 {name=p35 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 2310 0 0 {name=M18
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 2310 0 0 {name=p36 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 2630 0 0 {name=p37 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 2590 0 0 {name=M19
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 2590 0 0 {name=p38 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 2490 0 0 {name=p39 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 2450 0 0 {name=M20
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 2450 0 0 {name=p40 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 2910 0 0 {name=p41 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 2870 0 0 {name=M21
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 2870 0 0 {name=p42 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 2770 0 0 {name=p43 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 2730 0 0 {name=M22
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 2730 0 0 {name=p44 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 3190 0 0 {name=p45 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 3150 0 0 {name=M23
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 3150 0 0 {name=p46 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 3050 0 0 {name=p47 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 3010 0 0 {name=M24
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 3010 0 0 {name=p48 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 3330 0 0 {name=p49 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 3290 0 0 {name=M25
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 3290 0 0 {name=p50 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 3470 0 0 {name=p51 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 3430 0 0 {name=M26
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 3430 0 0 {name=p52 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 3750 0 0 {name=p53 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 3710 0 0 {name=M27
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 3710 0 0 {name=p54 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 3610 0 0 {name=p55 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 3570 0 0 {name=M28
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 3570 0 0 {name=p56 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 4030 0 0 {name=p57 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 3990 0 0 {name=M29
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 3990 0 0 {name=p58 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 3890 0 0 {name=p59 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 3850 0 0 {name=M30
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 3850 0 0 {name=p60 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 4310 0 0 {name=p61 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 4270 0 0 {name=M31
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 4270 0 0 {name=p62 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 4170 0 0 {name=p63 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 4130 0 0 {name=M32
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 4130 0 0 {name=p64 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3800 4450 0 0 {name=p65 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3780 4410 0 0 {name=M33
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3815 4410 0 0 {name=p66 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 2350 0 0 {name=p67 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 2310 0 0 {name=M34
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 2310 0 0 {name=p68 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 2630 0 0 {name=p69 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 2590 0 0 {name=M35
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 2590 0 0 {name=p70 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 2490 0 0 {name=p71 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 2450 0 0 {name=M36
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 2450 0 0 {name=p72 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 2910 0 0 {name=p73 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 2870 0 0 {name=M37
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 2870 0 0 {name=p74 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 2770 0 0 {name=p75 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 2730 0 0 {name=M38
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 2730 0 0 {name=p76 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 3190 0 0 {name=p77 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 3150 0 0 {name=M39
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 3150 0 0 {name=p78 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 3050 0 0 {name=p79 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 3010 0 0 {name=M40
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 3010 0 0 {name=p80 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 3330 0 0 {name=p81 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 3290 0 0 {name=M41
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 3290 0 0 {name=p82 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 3470 0 0 {name=p83 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 3430 0 0 {name=M42
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 3430 0 0 {name=p84 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 3750 0 0 {name=p85 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 3710 0 0 {name=M43
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 3710 0 0 {name=p86 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 3610 0 0 {name=p87 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 3570 0 0 {name=M44
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 3570 0 0 {name=p88 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 4030 0 0 {name=p89 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 3990 0 0 {name=M45
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 3990 0 0 {name=p90 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 3890 0 0 {name=p91 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 3850 0 0 {name=M46
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 3850 0 0 {name=p92 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 4310 0 0 {name=p93 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 4270 0 0 {name=M47
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 4270 0 0 {name=p94 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 4170 0 0 {name=p95 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 4130 0 0 {name=M48
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 4130 0 0 {name=p96 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 4450 0 0 {name=p97 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 4410 0 0 {name=M49
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 4410 0 0 {name=p98 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 110 0 0 {name=p99 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 70 0 0 {name=M50
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 70 0 0 {name=p100 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 390 0 0 {name=p101 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 350 0 0 {name=M51
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 350 0 0 {name=p102 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 250 0 0 {name=p103 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 210 0 0 {name=M52
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 210 0 0 {name=p104 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 670 0 0 {name=p105 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 630 0 0 {name=M53
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 630 0 0 {name=p106 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 530 0 0 {name=p107 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 490 0 0 {name=M54
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 490 0 0 {name=p108 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 950 0 0 {name=p109 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 910 0 0 {name=M55
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 910 0 0 {name=p110 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 810 0 0 {name=p111 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 770 0 0 {name=M56
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 770 0 0 {name=p112 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 1090 0 0 {name=p113 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 1050 0 0 {name=M57
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 1050 0 0 {name=p114 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 1230 0 0 {name=p115 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 1190 0 0 {name=M58
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 1190 0 0 {name=p116 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 1510 0 0 {name=p117 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 1470 0 0 {name=M59
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 1470 0 0 {name=p118 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 1370 0 0 {name=p119 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 1330 0 0 {name=M60
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 1330 0 0 {name=p120 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 1790 0 0 {name=p121 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 1750 0 0 {name=M61
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 1750 0 0 {name=p122 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 1650 0 0 {name=p123 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 1610 0 0 {name=M62
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 1610 0 0 {name=p124 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 2070 0 0 {name=p125 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 2030 0 0 {name=M63
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 2030 0 0 {name=p126 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 1930 0 0 {name=p127 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 1890 0 0 {name=M64
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 1890 0 0 {name=p128 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3600 2210 0 0 {name=p129 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3580 2170 0 0 {name=M65
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3615 2170 0 0 {name=p130 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4400 -4440 0 0 {name=p131 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 4380 -4390 0 0 {name=M66
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4405 -4390 0 0 {name=p132 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4200 -4440 0 0 {name=p135 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 4180 -4390 0 0 {name=M68
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4205 -4390 0 0 {name=p136 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4000 -4440 0 0 {name=p133 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 3980 -4390 0 0 {name=M67
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4005 -4390 0 0 {name=p134 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3800 -4440 0 0 {name=p137 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 3780 -4390 0 0 {name=M69
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3805 -4390 0 0 {name=p138 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3600 -4440 0 0 {name=p139 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 3580 -4390 0 0 {name=M70
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3605 -4390 0 0 {name=p140 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3650 5265 0 0 {name=p269 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3600 5295 0 0 {name=M135
L=0.28u
W=0.22u
nf=4
m=70
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3635 5295 0 0 {name=p270 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3850 5265 0 0 {name=p336 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 3800 5295 0 0 {name=M168
L=0.28u
W=0.22u
nf=4
m=70
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3835 5295 0 0 {name=p401 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3750 5295 0 0 {name=p402 sig_type=std_logic lab=CLK_EVAL}
C {lab_wire.sym} 4050 5265 0 0 {name=p403 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4000 5295 0 0 {name=M201
L=0.28u
W=0.22u
nf=4
m=70
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4035 5295 0 0 {name=p404 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3950 5295 0 0 {name=p405 sig_type=std_logic lab=CLK_EVAL}
C {lab_wire.sym} 4250 5265 0 0 {name=p406 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4200 5295 0 0 {name=M202
L=0.28u
W=0.22u
nf=4
m=70
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4235 5295 0 0 {name=p407 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4150 5295 0 0 {name=p408 sig_type=std_logic lab=CLK_EVAL}
C {lab_wire.sym} 4450 5265 0 0 {name=p409 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4400 5295 0 0 {name=M203
L=0.28u
W=0.22u
nf=4
m=70
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4435 5295 0 0 {name=p410 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4350 5295 0 0 {name=p411 sig_type=std_logic lab=CLK_EVAL}
C {lab_wire.sym} 4650 5265 0 0 {name=p412 sig_type=std_logic lab=FOOT}
C {symbols/nfet_03v3.sym} 4600 5295 0 0 {name=M204
L=0.28u
W=0.22u
nf=1
m=70
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4635 5295 0 0 {name=p413 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4550 5295 0 0 {name=p414 sig_type=std_logic lab=CLK_EVAL}
C {lab_wire.sym} 4540 -4390 0 0 {name=p415 sig_type=std_logic lab=CLK_PRE}
C {lab_wire.sym} 4340 -4390 0 0 {name=p416 sig_type=std_logic lab=CLK_PRE}
C {lab_wire.sym} 4140 -4390 0 0 {name=p417 sig_type=std_logic lab=CLK_PRE}
C {lab_wire.sym} 3940 -4390 0 0 {name=p418 sig_type=std_logic lab=CLK_PRE}
C {lab_wire.sym} 3740 -4390 0 0 {name=p419 sig_type=std_logic lab=CLK_PRE}
C {opin.sym} 3335 4965 0 0 {name=p421 lab=B5}
C {opin.sym} 3880 4980 0 0 {name=p422 lab=B4}
C {opin.sym} 4380 4985 0 0 {name=p424 lab=B3}
C {opin.sym} 4870 4995 0 0 {name=p425 lab=B2}
C {opin.sym} 5360 5000 0 0 {name=p426 lab=B1}
C {opin.sym} 5875 5005 0 0 {name=p427 lab=B0}
C {ipin.sym} 3070 -4270 0 0 {name=p423 lab=IN0}
C {ipin.sym} 3080 -4130 0 0 {name=p428 lab=IN1}
C {ipin.sym} 3080 -4050 0 0 {name=p429 lab=IN2}
C {ipin.sym} 3080 -3910 0 0 {name=p430 lab=IN3}
C {ipin.sym} 3070 -3770 0 0 {name=p431 lab=IN4}
C {ipin.sym} 3080 -3630 0 0 {name=p432 lab=IN5}
C {ipin.sym} 3090 -3490 0 0 {name=p433 lab=IN6}
C {ipin.sym} 3090 -3350 0 0 {name=p434 lab=IN7}
C {ipin.sym} 3100 -3210 0 0 {name=p435 lab=IN8}
C {ipin.sym} 3090 -3070 0 0 {name=p436 lab=IN9}
C {ipin.sym} 3100 -2930 0 0 {name=p437 lab=IN10}
C {ipin.sym} 3100 -2790 0 0 {name=p438 lab=IN11}
C {ipin.sym} 3110 -2650 0 0 {name=p439 lab=IN12}
C {ipin.sym} 3100 -2510 0 0 {name=p440 lab=IN13}
C {ipin.sym} 3110 -2370 0 0 {name=p441 lab=IN14}
C {ipin.sym} 3110 -2230 0 0 {name=p442 lab=IN15}
C {ipin.sym} 3120 -2090 0 0 {name=p443 lab=IN16}
C {ipin.sym} 3100 -1950 0 0 {name=p444 lab=IN17}
C {ipin.sym} 3110 -1810 0 0 {name=p445 lab=IN18}
C {ipin.sym} 3110 -1670 0 0 {name=p446 lab=IN19}
C {ipin.sym} 3120 -1530 0 0 {name=p447 lab=IN20}
C {ipin.sym} 3110 -1390 0 0 {name=p448 lab=IN21}
C {ipin.sym} 3120 -1250 0 0 {name=p449 lab=IN22}
C {ipin.sym} 3110 -1110 0 0 {name=p450 lab=IN23}
C {ipin.sym} 3120 -970 0 0 {name=p451 lab=IN24}
C {ipin.sym} 3120 -830 0 0 {name=p452 lab=IN25}
C {ipin.sym} 3130 -690 0 0 {name=p453 lab=IN26}
C {ipin.sym} 3120 -550 0 0 {name=p454 lab=IN27}
C {ipin.sym} 3130 -410 0 0 {name=p455 lab=IN28}
C {ipin.sym} 3130 -270 0 0 {name=p456 lab=IN29}
C {ipin.sym} 3140 -130 0 0 {name=p457 lab=IN30}
C {ipin.sym} 3120 10 0 0 {name=p458 lab=IN31}
C {ipin.sym} 3130 150 0 0 {name=p459 lab=IN32}
C {ipin.sym} 3120 290 0 0 {name=p460 lab=IN33}
C {ipin.sym} 3140 430 0 0 {name=p461 lab=IN34}
C {ipin.sym} 3140 570 0 0 {name=p462 lab=IN35}
C {ipin.sym} 3150 710 0 0 {name=p463 lab=IN36}
C {ipin.sym} 3140 850 0 0 {name=p464 lab=IN37}
C {ipin.sym} 3150 990 0 0 {name=p465 lab=IN38}
C {ipin.sym} 3150 1130 0 0 {name=p466 lab=IN39}
C {ipin.sym} 3160 1270 0 0 {name=p467 lab=IN40}
C {ipin.sym} 3150 1410 0 0 {name=p468 lab=IN41}
C {ipin.sym} 3160 1550 0 0 {name=p469 lab=IN42}
C {ipin.sym} 3160 1690 0 0 {name=p470 lab=IN43}
C {ipin.sym} 3170 1830 0 0 {name=p471 lab=IN44}
C {ipin.sym} 3150 1970 0 0 {name=p472 lab=IN45}
C {ipin.sym} 3160 2110 0 0 {name=p473 lab=IN46}
C {ipin.sym} 3160 2250 0 0 {name=p474 lab=IN47}
C {ipin.sym} 3170 2390 0 0 {name=p475 lab=IN48}
C {ipin.sym} 3160 2530 0 0 {name=p476 lab=IN49}
C {ipin.sym} 3170 2670 0 0 {name=p477 lab=IN50}
C {ipin.sym} 3160 2810 0 0 {name=p478 lab=IN51}
C {ipin.sym} 3170 2950 0 0 {name=p479 lab=IN52}
C {ipin.sym} 3170 3090 0 0 {name=p480 lab=IN53}
C {ipin.sym} 3180 3230 0 0 {name=p481 lab=IN54}
C {ipin.sym} 3170 3370 0 0 {name=p482 lab=IN55}
C {ipin.sym} 3180 3510 0 0 {name=p483 lab=IN56}
C {ipin.sym} 3180 3650 0 0 {name=p484 lab=IN57}
C {ipin.sym} 3190 3790 0 0 {name=p485 lab=IN58}
C {ipin.sym} 3170 3930 0 0 {name=p486 lab=IN59}
C {ipin.sym} 3180 4070 0 0 {name=p487 lab=IN60}
C {ipin.sym} 3180 4210 0 0 {name=p488 lab=IN61}
C {ipin.sym} 3190 4350 0 0 {name=p489 lab=IN62}
C {code_shown.sym} 1285 -1765 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
"}
C {ipin.sym} 3550 5295 0 0 {name=p335 lab=CLK_EVAL}
C {ipin.sym} 3520 -4390 0 0 {name=p490 lab=CLK_PRE}
C {code_shown.sym} 1285 -1605 0 0 {name=SPICE only_toplevel=false value="
V_PRE CLK_PRE 0 pulse(3.3 0 0p 10p 10p 240p 500p)
V_EVAL CLK_EVAL 0 pulse(0 3.3 0 10p 10p 240p 500p)
V_RST RST 0 pulse(3.3 3.3 0 10p 10p 240p 500p)

V_IN62 IN62 0 PWL(0 0 0.000n 0 0.010n 3.3 0.490n 3.3 0.500n 0)
V_IN61 IN61 0 PWL(0 0 0.500n 0 0.510n 3.3 0.990n 3.3 1.000n 0)
V_IN60 IN60 0 PWL(0 0 1.000n 0 1.010n 3.3 1.490n 3.3 1.500n 0)
V_IN59 IN59 0 PWL(0 0 1.500n 0 1.510n 3.3 1.990n 3.3 2.000n 0)
V_IN58 IN58 0 PWL(0 0 2.000n 0 2.010n 3.3 2.490n 3.3 2.500n 0)
V_IN57 IN57 0 PWL(0 0 2.500n 0 2.510n 3.3 2.990n 3.3 3.000n 0)
V_IN56 IN56 0 PWL(0 0 3.000n 0 3.010n 3.3 3.490n 3.3 3.500n 0)
V_IN55 IN55 0 PWL(0 0 3.500n 0 3.510n 3.3 3.990n 3.3 4.000n 0)
V_IN54 IN54 0 PWL(0 0 4.000n 0 4.010n 3.3 4.490n 3.3 4.500n 0)
V_IN53 IN53 0 PWL(0 0 4.500n 0 4.510n 3.3 4.990n 3.3 5.000n 0)
V_IN52 IN52 0 PWL(0 0 5.000n 0 5.010n 3.3 5.490n 3.3 5.500n 0)
V_IN51 IN51 0 PWL(0 0 5.500n 0 5.510n 3.3 5.990n 3.3 6.000n 0)
V_IN50 IN50 0 PWL(0 0 6.000n 0 6.010n 3.3 6.490n 3.3 6.500n 0)
V_IN49 IN49 0 PWL(0 0 6.500n 0 6.510n 3.3 6.990n 3.3 7.000n 0)
V_IN48 IN48 0 PWL(0 0 7.000n 0 7.010n 3.3 7.490n 3.3 7.500n 0)
V_IN47 IN47 0 PWL(0 0 7.500n 0 7.510n 3.3 7.990n 3.3 8.000n 0)
V_IN46 IN46 0 PWL(0 0 8.000n 0 8.010n 3.3 8.490n 3.3 8.500n 0)
V_IN45 IN45 0 PWL(0 0 8.500n 0 8.510n 3.3 8.990n 3.3 9.000n 0)
V_IN44 IN44 0 PWL(0 0 9.000n 0 9.010n 3.3 9.490n 3.3 9.500n 0)
V_IN43 IN43 0 PWL(0 0 9.500n 0 9.510n 3.3 9.990n 3.3 10.000n 0)
V_IN42 IN42 0 PWL(0 0 10.000n 0 10.010n 3.3 10.490n 3.3 10.500n 0)
V_IN41 IN41 0 PWL(0 0 10.500n 0 10.510n 3.3 10.990n 3.3 11.000n 0)
V_IN40 IN40 0 PWL(0 0 11.000n 0 11.010n 3.3 11.490n 3.3 11.500n 0)
V_IN39 IN39 0 PWL(0 0 11.500n 0 11.510n 3.3 11.990n 3.3 12.000n 0)
V_IN38 IN38 0 PWL(0 0 12.000n 0 12.010n 3.3 12.490n 3.3 12.500n 0)
V_IN37 IN37 0 PWL(0 0 12.500n 0 12.510n 3.3 12.990n 3.3 13.000n 0)
V_IN36 IN36 0 PWL(0 0 13.000n 0 13.010n 3.3 13.490n 3.3 13.500n 0)
V_IN35 IN35 0 PWL(0 0 13.500n 0 13.510n 3.3 13.990n 3.3 14.000n 0)
V_IN34 IN34 0 PWL(0 0 14.000n 0 14.010n 3.3 14.490n 3.3 14.500n 0)
V_IN33 IN33 0 PWL(0 0 14.500n 0 14.510n 3.3 14.990n 3.3 15.000n 0)
V_IN32 IN32 0 PWL(0 0 15.000n 0 15.010n 3.3 15.490n 3.3 15.500n 0)
V_IN31 IN31 0 PWL(0 0 15.500n 0 15.510n 3.3 15.990n 3.3 16.000n 0)
V_IN30 IN30 0 PWL(0 0 16.000n 0 16.010n 3.3 16.490n 3.3 16.500n 0)
V_IN29 IN29 0 PWL(0 0 16.500n 0 16.510n 3.3 16.990n 3.3 17.000n 0)
V_IN28 IN28 0 PWL(0 0 17.000n 0 17.010n 3.3 17.490n 3.3 17.500n 0)
V_IN27 IN27 0 PWL(0 0 17.500n 0 17.510n 3.3 17.990n 3.3 18.000n 0)
V_IN26 IN26 0 PWL(0 0 18.000n 0 18.010n 3.3 18.490n 3.3 18.500n 0)
V_IN25 IN25 0 PWL(0 0 18.500n 0 18.510n 3.3 18.990n 3.3 19.000n 0)
V_IN24 IN24 0 PWL(0 0 19.000n 0 19.010n 3.3 19.490n 3.3 19.500n 0)
V_IN23 IN23 0 PWL(0 0 19.500n 0 19.510n 3.3 19.990n 3.3 20.000n 0)
V_IN22 IN22 0 PWL(0 0 20.000n 0 20.010n 3.3 20.490n 3.3 20.500n 0)
V_IN21 IN21 0 PWL(0 0 20.500n 0 20.510n 3.3 20.990n 3.3 21.000n 0)
V_IN20 IN20 0 PWL(0 0 21.000n 0 21.010n 3.3 21.490n 3.3 21.500n 0)
V_IN19 IN19 0 PWL(0 0 21.500n 0 21.510n 3.3 21.990n 3.3 22.000n 0)
V_IN18 IN18 0 PWL(0 0 22.000n 0 22.010n 3.3 22.490n 3.3 22.500n 0)
V_IN17 IN17 0 PWL(0 0 22.500n 0 22.510n 3.3 22.990n 3.3 23.000n 0)
V_IN16 IN16 0 PWL(0 0 23.000n 0 23.010n 3.3 23.490n 3.3 23.500n 0)
V_IN15 IN15 0 PWL(0 0 23.500n 0 23.510n 3.3 23.990n 3.3 24.000n 0)
V_IN14 IN14 0 PWL(0 0 24.000n 0 24.010n 3.3 24.490n 3.3 24.500n 0)
V_IN13 IN13 0 PWL(0 0 24.500n 0 24.510n 3.3 24.990n 3.3 25.000n 0)
V_IN12 IN12 0 PWL(0 0 25.000n 0 25.010n 3.3 25.490n 3.3 25.500n 0)
V_IN11 IN11 0 PWL(0 0 25.500n 0 25.510n 3.3 25.990n 3.3 26.000n 0)
V_IN10 IN10 0 PWL(0 0 26.000n 0 26.010n 3.3 26.490n 3.3 26.500n 0)
V_IN9 IN9 0 PWL(0 0 26.500n 0 26.510n 3.3 26.990n 3.3 27.000n 0)
V_IN8 IN8 0 PWL(0 0 27.000n 0 27.010n 3.3 27.490n 3.3 27.500n 0)
V_IN7 IN7 0 PWL(0 0 27.500n 0 27.510n 3.3 27.990n 3.3 28.000n 0)
V_IN6 IN6 0 PWL(0 0 28.000n 0 28.010n 3.3 28.490n 3.3 28.500n 0)
V_IN5 IN5 0 PWL(0 0 28.500n 0 28.510n 3.3 28.990n 3.3 29.000n 0)
V_IN4 IN4 0 PWL(0 0 29.000n 0 29.010n 3.3 29.490n 3.3 29.500n 0)
V_IN3 IN3 0 PWL(0 0 29.500n 0 29.510n 3.3 29.990n 3.3 30.000n 0)
V_IN2 IN2 0 PWL(0 0 30.000n 0 30.010n 3.3 30.490n 3.3 30.500n 0)
V_IN1 IN1 0 PWL(0 0 30.500n 0 30.510n 3.3 30.990n 3.3 31.000n 0)
V_IN0 IN0 0 PWL(0 0 31.000n 0 31.010n 3.3 31.490n 3.3 31.500n 0)

.tran 2p 35n uic
"}
C {lab_wire.sym} 3410 4600 0 0 {name=p420 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3410 4840 0 0 {name=p491 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3280 4730 0 0 {name=p492 sig_type=std_logic lab=B5bar}
C {symbols/pfet_03v3.sym} 3390 4650 0 0 {name=M205
L=0.28u
W=0.22u
nf=1
m=35
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3390 4800 0 0 {name=M206
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3415 4650 0 0 {name=p494 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3425 4800 0 0 {name=p495 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3720 4600 0 0 {name=p496 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3720 4840 0 0 {name=p497 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3590 4730 0 0 {name=p498 sig_type=std_logic lab=B4bar}
C {symbols/pfet_03v3.sym} 3700 4650 0 0 {name=M207
L=0.28u
W=0.22u
nf=1
m=35
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 4800 0 0 {name=M208
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3725 4650 0 0 {name=p500 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3735 4800 0 0 {name=p501 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4030 4600 0 0 {name=p502 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4030 4840 0 0 {name=p503 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3900 4730 0 0 {name=p504 sig_type=std_logic lab=B3bar}
C {symbols/pfet_03v3.sym} 4010 4650 0 0 {name=M209
L=0.28u
W=0.22u
nf=1
m=35
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4010 4800 0 0 {name=M210
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4035 4650 0 0 {name=p506 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4045 4800 0 0 {name=p507 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4350 4600 0 0 {name=p508 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4350 4840 0 0 {name=p509 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4220 4730 0 0 {name=p510 sig_type=std_logic lab=B2bar}
C {symbols/pfet_03v3.sym} 4330 4650 0 0 {name=M211
L=0.28u
W=0.22u
nf=1
m=35
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4330 4800 0 0 {name=M212
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4355 4650 0 0 {name=p512 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4365 4800 0 0 {name=p513 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4670 4600 0 0 {name=p514 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4670 4840 0 0 {name=p515 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4540 4730 0 0 {name=p516 sig_type=std_logic lab=B1bar}
C {symbols/pfet_03v3.sym} 4650 4650 0 0 {name=M213
L=0.28u
W=0.22u
nf=1
m=35
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4650 4800 0 0 {name=M214
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4675 4650 0 0 {name=p518 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4685 4800 0 0 {name=p519 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4990 4600 0 0 {name=p520 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4990 4840 0 0 {name=p521 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4860 4730 0 0 {name=p522 sig_type=std_logic lab=B0bar}
C {symbols/pfet_03v3.sym} 4970 4650 0 0 {name=M215
L=0.28u
W=0.22u
nf=1
m=35
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4970 4800 0 0 {name=M216
L=0.28u
W=0.22u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4995 4650 0 0 {name=p524 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5005 4800 0 0 {name=p525 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3660 4500 0 0 {name=p493 sig_type=std_logic lab=B5bar}
C {lab_wire.sym} 3860 4480 0 0 {name=p499 sig_type=std_logic lab=B4bar}
C {lab_wire.sym} 4060 4480 0 0 {name=p505 sig_type=std_logic lab=B3bar}
C {lab_wire.sym} 4260 4490 0 0 {name=p511 sig_type=std_logic lab=B2bar}
C {lab_wire.sym} 4460 4500 0 0 {name=p517 sig_type=std_logic lab=B1bar}
C {lab_wire.sym} 4660 4500 0 0 {name=p523 sig_type=std_logic lab=B0bar}
C {vsource.sym} 2880 -1720 0 0 {name=V1 value=3.3 savecurrent=false}
C {vdd.sym} 2880 -1780 0 0 {name=l3 lab=VDD}
C {gnd.sym} 2880 -1670 0 1 {name=l4 lab=GND
}
C {lab_wire.sym} 3485 4730 0 0 {name=p526 sig_type=std_logic lab=B5out}
C {lab_wire.sym} 2965 4965 0 0 {name=p528 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2965 5045 0 0 {name=p529 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2965 5005 0 0 {name=p530 sig_type=std_logic lab=CLK_EVAL}
C {ipin.sym} 2935 4985 0 0 {name=p531 lab=RST}
C {lab_wire.sym} 2970 5025 0 0 {name=p527 sig_type=std_logic lab=B5out}
C {lab_wire.sym} 3515 4980 0 0 {name=p533 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3515 5060 0 0 {name=p534 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3515 5020 0 0 {name=p535 sig_type=std_logic lab=CLK_EVAL}
C {ipin.sym} 3485 5000 0 0 {name=p536 lab=RST}
C {lab_wire.sym} 4020 4985 0 0 {name=p539 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4020 5065 0 0 {name=p540 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4020 5025 0 0 {name=p541 sig_type=std_logic lab=CLK_EVAL}
C {ipin.sym} 3990 5005 0 0 {name=p542 lab=RST}
C {lab_wire.sym} 4520 4995 0 0 {name=p545 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4520 5075 0 0 {name=p546 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4520 5035 0 0 {name=p547 sig_type=std_logic lab=CLK_EVAL}
C {ipin.sym} 4490 5015 0 0 {name=p548 lab=RST}
C {lab_wire.sym} 5025 5000 0 0 {name=p551 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5025 5080 0 0 {name=p552 sig_type=std_logic lab=GND}
C {lab_wire.sym} 5025 5040 0 0 {name=p553 sig_type=std_logic lab=CLK_EVAL}
C {ipin.sym} 4995 5020 0 0 {name=p554 lab=RST}
C {lab_wire.sym} 5520 5005 0 0 {name=p557 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5520 5085 0 0 {name=p558 sig_type=std_logic lab=GND}
C {lab_wire.sym} 5520 5045 0 0 {name=p559 sig_type=std_logic lab=CLK_EVAL}
C {ipin.sym} 5490 5025 0 0 {name=p560 lab=RST}
C {lab_wire.sym} 3520 5040 0 0 {name=p532 sig_type=std_logic lab=B4out}
C {lab_wire.sym} 3750 4730 0 0 {name=p537 sig_type=std_logic lab=B4out}
C {lab_wire.sym} 4030 5045 0 0 {name=p538 sig_type=std_logic lab=B3out}
C {lab_wire.sym} 4530 5055 0 0 {name=p543 sig_type=std_logic lab=B2out}
C {lab_wire.sym} 5030 5060 0 0 {name=p544 sig_type=std_logic lab=B1out}
C {lab_wire.sym} 5535 5065 0 0 {name=p549 sig_type=std_logic lab=B0out}
C {lab_wire.sym} 4125 4730 0 0 {name=p550 sig_type=std_logic lab=B3out}
C {lab_wire.sym} 4445 4730 0 0 {name=p555 sig_type=std_logic lab=B2out}
C {lab_wire.sym} 4745 4730 0 0 {name=p556 sig_type=std_logic lab=B1out}
C {lab_wire.sym} 5075 4730 0 0 {name=p561 sig_type=std_logic lab=B0out}
C {launcher.sym} 2080 -1190 0 0 {name=h5
descr="load waves"
tclcommand="xschem raw_read $netlist_dir/ROM2_test.raw tran"
}
C {encoder/sym/dff_encoder.sym} 3135 5005 0 0 {name=x6}
C {encoder/sym/dff_encoder.sym} 3685 5020 0 0 {name=x1}
C {encoder/sym/dff_encoder.sym} 4190 5025 0 0 {name=x2}
C {encoder/sym/dff_encoder.sym} 4690 5035 0 0 {name=x3}
C {encoder/sym/dff_encoder.sym} 5195 5040 0 0 {name=x4}
C {encoder/sym/dff_encoder.sym} 5690 5045 0 0 {name=x5}
