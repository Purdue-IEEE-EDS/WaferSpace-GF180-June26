v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 2500 -6790 2500 -6770 {lab=VDD}
N 2500 -6330 2500 -6310 {lab=GND}
N 2500 -6360 2520 -6360 {lab=GND}
N 2500 -6050 2500 -6030 {lab=GND}
N 2500 -6080 2520 -6080 {lab=GND}
N 2500 -5770 2500 -5750 {lab=GND}
N 2500 -5800 2520 -5800 {lab=GND}
N 2300 -6050 2300 -6030 {lab=GND}
N 2300 -6080 2320 -6080 {lab=GND}
N 2300 -6190 2300 -6170 {lab=GND}
N 2300 -6220 2320 -6220 {lab=GND}
N 2300 -5630 2300 -5610 {lab=GND}
N 2300 -5660 2320 -5660 {lab=GND}
N 2500 -5490 2500 -5470 {lab=GND}
N 2500 -5520 2520 -5520 {lab=GND}
N 2300 -5490 2300 -5470 {lab=GND}
N 2300 -5520 2320 -5520 {lab=GND}
N 2100 -5770 2100 -5750 {lab=GND}
N 2100 -5800 2120 -5800 {lab=GND}
N 2100 -5910 2100 -5890 {lab=GND}
N 2100 -5940 2120 -5940 {lab=GND}
N 2100 -5490 2100 -5470 {lab=GND}
N 2100 -5520 2120 -5520 {lab=GND}
N 2100 -5630 2100 -5610 {lab=GND}
N 2100 -5660 2120 -5660 {lab=GND}
N 2500 -5210 2500 -5190 {lab=GND}
N 2500 -5240 2520 -5240 {lab=GND}
N 2500 -4930 2500 -4910 {lab=GND}
N 2500 -4960 2520 -4960 {lab=GND}
N 2500 -4650 2500 -4630 {lab=GND}
N 2500 -4680 2520 -4680 {lab=GND}
N 2300 -4930 2300 -4910 {lab=GND}
N 2300 -4960 2320 -4960 {lab=GND}
N 2300 -5070 2300 -5050 {lab=GND}
N 2300 -5100 2320 -5100 {lab=GND}
N 2300 -4510 2300 -4490 {lab=GND}
N 2300 -4540 2320 -4540 {lab=GND}
N 2500 -4370 2500 -4350 {lab=GND}
N 2500 -4400 2520 -4400 {lab=GND}
N 2300 -4370 2300 -4350 {lab=GND}
N 2300 -4400 2320 -4400 {lab=GND}
N 2100 -4650 2100 -4630 {lab=GND}
N 2100 -4680 2120 -4680 {lab=GND}
N 2100 -4790 2100 -4770 {lab=GND}
N 2100 -4820 2120 -4820 {lab=GND}
N 2100 -4370 2100 -4350 {lab=GND}
N 2100 -4400 2120 -4400 {lab=GND}
N 2100 -4510 2100 -4490 {lab=GND}
N 2100 -4540 2120 -4540 {lab=GND}
N 1900 -5210 1900 -5190 {lab=GND}
N 1900 -5240 1920 -5240 {lab=GND}
N 1900 -5350 1900 -5330 {lab=GND}
N 1900 -5380 1920 -5380 {lab=GND}
N 1900 -4930 1900 -4910 {lab=GND}
N 1900 -4960 1920 -4960 {lab=GND}
N 1900 -5070 1900 -5050 {lab=GND}
N 1900 -5100 1920 -5100 {lab=GND}
N 1900 -4650 1900 -4630 {lab=GND}
N 1900 -4680 1920 -4680 {lab=GND}
N 1900 -4790 1900 -4770 {lab=GND}
N 1900 -4820 1920 -4820 {lab=GND}
N 1900 -4370 1900 -4350 {lab=GND}
N 1900 -4400 1920 -4400 {lab=GND}
N 1900 -4510 1900 -4490 {lab=GND}
N 1900 -4540 1920 -4540 {lab=GND}
N 1700 -4230 1700 -4210 {lab=GND}
N 1700 -4260 1720 -4260 {lab=GND}
N 2500 -4090 2500 -4070 {lab=GND}
N 2500 -4120 2520 -4120 {lab=GND}
N 2500 -3810 2500 -3790 {lab=GND}
N 2500 -3840 2520 -3840 {lab=GND}
N 2500 -3530 2500 -3510 {lab=GND}
N 2500 -3560 2520 -3560 {lab=GND}
N 2300 -3810 2300 -3790 {lab=GND}
N 2300 -3840 2320 -3840 {lab=GND}
N 2300 -3950 2300 -3930 {lab=GND}
N 2300 -3980 2320 -3980 {lab=GND}
N 2300 -3390 2300 -3370 {lab=GND}
N 2300 -3420 2320 -3420 {lab=GND}
N 2500 -3250 2500 -3230 {lab=GND}
N 2500 -3280 2520 -3280 {lab=GND}
N 2300 -3250 2300 -3230 {lab=GND}
N 2300 -3280 2320 -3280 {lab=GND}
N 2100 -3530 2100 -3510 {lab=GND}
N 2100 -3560 2120 -3560 {lab=GND}
N 2100 -3670 2100 -3650 {lab=GND}
N 2100 -3700 2120 -3700 {lab=GND}
N 2100 -3250 2100 -3230 {lab=GND}
N 2100 -3280 2120 -3280 {lab=GND}
N 2100 -3390 2100 -3370 {lab=GND}
N 2100 -3420 2120 -3420 {lab=GND}
N 2500 -2970 2500 -2950 {lab=GND}
N 2500 -3000 2520 -3000 {lab=GND}
N 2500 -2690 2500 -2670 {lab=GND}
N 2500 -2720 2520 -2720 {lab=GND}
N 2500 -2410 2500 -2390 {lab=GND}
N 2500 -2440 2520 -2440 {lab=GND}
N 2300 -2690 2300 -2670 {lab=GND}
N 2300 -2720 2320 -2720 {lab=GND}
N 2300 -2830 2300 -2810 {lab=GND}
N 2300 -2860 2320 -2860 {lab=GND}
N 2300 -2270 2300 -2250 {lab=GND}
N 2300 -2300 2320 -2300 {lab=GND}
N 2500 -2130 2500 -2110 {lab=GND}
N 2500 -2160 2520 -2160 {lab=GND}
N 2300 -2130 2300 -2110 {lab=GND}
N 2300 -2160 2320 -2160 {lab=GND}
N 2100 -2410 2100 -2390 {lab=GND}
N 2100 -2440 2120 -2440 {lab=GND}
N 2100 -2550 2100 -2530 {lab=GND}
N 2100 -2580 2120 -2580 {lab=GND}
N 2100 -2130 2100 -2110 {lab=GND}
N 2100 -2160 2120 -2160 {lab=GND}
N 2100 -2270 2100 -2250 {lab=GND}
N 2100 -2300 2120 -2300 {lab=GND}
N 1900 -2970 1900 -2950 {lab=GND}
N 1900 -3000 1920 -3000 {lab=GND}
N 1900 -3110 1900 -3090 {lab=GND}
N 1900 -3140 1920 -3140 {lab=GND}
N 1900 -2690 1900 -2670 {lab=GND}
N 1900 -2720 1920 -2720 {lab=GND}
N 1900 -2830 1900 -2810 {lab=GND}
N 1900 -2860 1920 -2860 {lab=GND}
N 1900 -2410 1900 -2390 {lab=GND}
N 1900 -2440 1920 -2440 {lab=GND}
N 1900 -2550 1900 -2530 {lab=GND}
N 1900 -2580 1920 -2580 {lab=GND}
N 1900 -2130 1900 -2110 {lab=GND}
N 1900 -2160 1920 -2160 {lab=GND}
N 1900 -2270 1900 -2250 {lab=GND}
N 1900 -2300 1920 -2300 {lab=GND}
N 4280 -6270 4280 -6250 {lab=GND}
N 4280 -6300 4300 -6300 {lab=GND}
N 4280 -5990 4280 -5970 {lab=GND}
N 4280 -6020 4300 -6020 {lab=GND}
N 4280 -5710 4280 -5690 {lab=GND}
N 4280 -5740 4300 -5740 {lab=GND}
N 4080 -5990 4080 -5970 {lab=GND}
N 4080 -6020 4100 -6020 {lab=GND}
N 4080 -6130 4080 -6110 {lab=GND}
N 4080 -6160 4100 -6160 {lab=GND}
N 4080 -5570 4080 -5550 {lab=GND}
N 4080 -5600 4100 -5600 {lab=GND}
N 4280 -5430 4280 -5410 {lab=GND}
N 4280 -5460 4300 -5460 {lab=GND}
N 4080 -5430 4080 -5410 {lab=GND}
N 4080 -5460 4100 -5460 {lab=GND}
N 3880 -5710 3880 -5690 {lab=GND}
N 3880 -5740 3900 -5740 {lab=GND}
N 3880 -5850 3880 -5830 {lab=GND}
N 3880 -5880 3900 -5880 {lab=GND}
N 3880 -5430 3880 -5410 {lab=GND}
N 3880 -5460 3900 -5460 {lab=GND}
N 3880 -5570 3880 -5550 {lab=GND}
N 3880 -5600 3900 -5600 {lab=GND}
N 4280 -5150 4280 -5130 {lab=GND}
N 4280 -5180 4300 -5180 {lab=GND}
N 4280 -4870 4280 -4850 {lab=GND}
N 4280 -4900 4300 -4900 {lab=GND}
N 4280 -4590 4280 -4570 {lab=GND}
N 4280 -4620 4300 -4620 {lab=GND}
N 4080 -4870 4080 -4850 {lab=GND}
N 4080 -4900 4100 -4900 {lab=GND}
N 4080 -5010 4080 -4990 {lab=GND}
N 4080 -5040 4100 -5040 {lab=GND}
N 4080 -4450 4080 -4430 {lab=GND}
N 4080 -4480 4100 -4480 {lab=GND}
N 4280 -4310 4280 -4290 {lab=GND}
N 4280 -4340 4300 -4340 {lab=GND}
N 4080 -4310 4080 -4290 {lab=GND}
N 4080 -4340 4100 -4340 {lab=GND}
N 3880 -4590 3880 -4570 {lab=GND}
N 3880 -4620 3900 -4620 {lab=GND}
N 3880 -4730 3880 -4710 {lab=GND}
N 3880 -4760 3900 -4760 {lab=GND}
N 3880 -4310 3880 -4290 {lab=GND}
N 3880 -4340 3900 -4340 {lab=GND}
N 3880 -4450 3880 -4430 {lab=GND}
N 3880 -4480 3900 -4480 {lab=GND}
N 3680 -5150 3680 -5130 {lab=GND}
N 3680 -5180 3700 -5180 {lab=GND}
N 3680 -5290 3680 -5270 {lab=GND}
N 3680 -5320 3700 -5320 {lab=GND}
N 3680 -4870 3680 -4850 {lab=GND}
N 3680 -4900 3700 -4900 {lab=GND}
N 3680 -5010 3680 -4990 {lab=GND}
N 3680 -5040 3700 -5040 {lab=GND}
N 3680 -4590 3680 -4570 {lab=GND}
N 3680 -4620 3700 -4620 {lab=GND}
N 3680 -4730 3680 -4710 {lab=GND}
N 3680 -4760 3700 -4760 {lab=GND}
N 3680 -4310 3680 -4290 {lab=GND}
N 3680 -4340 3700 -4340 {lab=GND}
N 3680 -4450 3680 -4430 {lab=GND}
N 3680 -4480 3700 -4480 {lab=GND}
N 4280 -4030 4280 -4010 {lab=GND}
N 4280 -4060 4300 -4060 {lab=GND}
N 4280 -3750 4280 -3730 {lab=GND}
N 4280 -3780 4300 -3780 {lab=GND}
N 4280 -3470 4280 -3450 {lab=GND}
N 4280 -3500 4300 -3500 {lab=GND}
N 4080 -3750 4080 -3730 {lab=GND}
N 4080 -3780 4100 -3780 {lab=GND}
N 4080 -3890 4080 -3870 {lab=GND}
N 4080 -3920 4100 -3920 {lab=GND}
N 4080 -3330 4080 -3310 {lab=GND}
N 4080 -3360 4100 -3360 {lab=GND}
N 4280 -3190 4280 -3170 {lab=GND}
N 4280 -3220 4300 -3220 {lab=GND}
N 4080 -3190 4080 -3170 {lab=GND}
N 4080 -3220 4100 -3220 {lab=GND}
N 3880 -3470 3880 -3450 {lab=GND}
N 3880 -3500 3900 -3500 {lab=GND}
N 3880 -3610 3880 -3590 {lab=GND}
N 3880 -3640 3900 -3640 {lab=GND}
N 3880 -3190 3880 -3170 {lab=GND}
N 3880 -3220 3900 -3220 {lab=GND}
N 3880 -3330 3880 -3310 {lab=GND}
N 3880 -3360 3900 -3360 {lab=GND}
N 4280 -2910 4280 -2890 {lab=GND}
N 4280 -2940 4300 -2940 {lab=GND}
N 4280 -2630 4280 -2610 {lab=GND}
N 4280 -2660 4300 -2660 {lab=GND}
N 4280 -2350 4280 -2330 {lab=GND}
N 4280 -2380 4300 -2380 {lab=GND}
N 4080 -2630 4080 -2610 {lab=GND}
N 4080 -2660 4100 -2660 {lab=GND}
N 4080 -2770 4080 -2750 {lab=GND}
N 4080 -2800 4100 -2800 {lab=GND}
N 4080 -2210 4080 -2190 {lab=GND}
N 4080 -2240 4100 -2240 {lab=GND}
N 4280 -2070 4280 -2050 {lab=GND}
N 4280 -2100 4300 -2100 {lab=GND}
N 4080 -2070 4080 -2050 {lab=GND}
N 4080 -2100 4100 -2100 {lab=GND}
N 3880 -2350 3880 -2330 {lab=GND}
N 3880 -2380 3900 -2380 {lab=GND}
N 3880 -2490 3880 -2470 {lab=GND}
N 3880 -2520 3900 -2520 {lab=GND}
N 3880 -2070 3880 -2050 {lab=GND}
N 3880 -2100 3900 -2100 {lab=GND}
N 3880 -2210 3880 -2190 {lab=GND}
N 3880 -2240 3900 -2240 {lab=GND}
N 3680 -2910 3680 -2890 {lab=GND}
N 3680 -2940 3700 -2940 {lab=GND}
N 3680 -3050 3680 -3030 {lab=GND}
N 3680 -3080 3700 -3080 {lab=GND}
N 3680 -2630 3680 -2610 {lab=GND}
N 3680 -2660 3700 -2660 {lab=GND}
N 3680 -2770 3680 -2750 {lab=GND}
N 3680 -2800 3700 -2800 {lab=GND}
N 3680 -2350 3680 -2330 {lab=GND}
N 3680 -2380 3700 -2380 {lab=GND}
N 3680 -2490 3680 -2470 {lab=GND}
N 3680 -2520 3700 -2520 {lab=GND}
N 3680 -2070 3680 -2050 {lab=GND}
N 3680 -2100 3700 -2100 {lab=GND}
N 3680 -2210 3680 -2190 {lab=GND}
N 3680 -2240 3700 -2240 {lab=GND}
N 1700 -3950 1700 -3930 {lab=GND}
N 1700 -3980 1720 -3980 {lab=GND}
N 1700 -4090 1700 -4070 {lab=GND}
N 1700 -4120 1720 -4120 {lab=GND}
N 1700 -3670 1700 -3650 {lab=GND}
N 1700 -3700 1720 -3700 {lab=GND}
N 1700 -3810 1700 -3790 {lab=GND}
N 1700 -3840 1720 -3840 {lab=GND}
N 1700 -3390 1700 -3370 {lab=GND}
N 1700 -3420 1720 -3420 {lab=GND}
N 1700 -3530 1700 -3510 {lab=GND}
N 1700 -3560 1720 -3560 {lab=GND}
N 1700 -3250 1700 -3230 {lab=GND}
N 1700 -3280 1720 -3280 {lab=GND}
N 1700 -3110 1700 -3090 {lab=GND}
N 1700 -3140 1720 -3140 {lab=GND}
N 1700 -2830 1700 -2810 {lab=GND}
N 1700 -2860 1720 -2860 {lab=GND}
N 1700 -2970 1700 -2950 {lab=GND}
N 1700 -3000 1720 -3000 {lab=GND}
N 1700 -2550 1700 -2530 {lab=GND}
N 1700 -2580 1720 -2580 {lab=GND}
N 1700 -2690 1700 -2670 {lab=GND}
N 1700 -2720 1720 -2720 {lab=GND}
N 1700 -2270 1700 -2250 {lab=GND}
N 1700 -2300 1720 -2300 {lab=GND}
N 1700 -2410 1700 -2390 {lab=GND}
N 1700 -2440 1720 -2440 {lab=GND}
N 1700 -2130 1700 -2110 {lab=GND}
N 1700 -2160 1720 -2160 {lab=GND}
N 3480 -4170 3480 -4150 {lab=GND}
N 3480 -4200 3500 -4200 {lab=GND}
N 3480 -3890 3480 -3870 {lab=GND}
N 3480 -3920 3500 -3920 {lab=GND}
N 3480 -4030 3480 -4010 {lab=GND}
N 3480 -4060 3500 -4060 {lab=GND}
N 3480 -3610 3480 -3590 {lab=GND}
N 3480 -3640 3500 -3640 {lab=GND}
N 3480 -3750 3480 -3730 {lab=GND}
N 3480 -3780 3500 -3780 {lab=GND}
N 3480 -3330 3480 -3310 {lab=GND}
N 3480 -3360 3500 -3360 {lab=GND}
N 3480 -3470 3480 -3450 {lab=GND}
N 3480 -3500 3500 -3500 {lab=GND}
N 3480 -3190 3480 -3170 {lab=GND}
N 3480 -3220 3500 -3220 {lab=GND}
N 3480 -3050 3480 -3030 {lab=GND}
N 3480 -3080 3500 -3080 {lab=GND}
N 3480 -2770 3480 -2750 {lab=GND}
N 3480 -2800 3500 -2800 {lab=GND}
N 3480 -2910 3480 -2890 {lab=GND}
N 3480 -2940 3500 -2940 {lab=GND}
N 3480 -2490 3480 -2470 {lab=GND}
N 3480 -2520 3500 -2520 {lab=GND}
N 3480 -2630 3480 -2610 {lab=GND}
N 3480 -2660 3500 -2660 {lab=GND}
N 3480 -2210 3480 -2190 {lab=GND}
N 3480 -2240 3500 -2240 {lab=GND}
N 3480 -2350 3480 -2330 {lab=GND}
N 3480 -2380 3500 -2380 {lab=GND}
N 3480 -2070 3480 -2050 {lab=GND}
N 3480 -2100 3500 -2100 {lab=GND}
N 2500 -6390 2560 -6390 {lab=B0B}
N 2500 -6110 2560 -6110 {lab=B0B}
N 2500 -5830 2560 -5830 {lab=B0B}
N 2500 -5550 2560 -5550 {lab=B0B}
N 2500 -5270 2560 -5270 {lab=B0B}
N 2500 -4990 2560 -4990 {lab=B0B}
N 2500 -4710 2560 -4710 {lab=B0B}
N 2500 -4430 2560 -4430 {lab=B0B}
N 2500 -4150 2560 -4150 {lab=B0B}
N 2500 -3870 2560 -3870 {lab=B0B}
N 2500 -3590 2560 -3590 {lab=B0B}
N 2500 -3310 2560 -3310 {lab=B0B}
N 2500 -3030 2560 -3030 {lab=B0B}
N 2500 -2750 2560 -2750 {lab=B0B}
N 2500 -2470 2560 -2470 {lab=B0B}
N 4280 -6330 4340 -6330 {lab=B0B}
N 4280 -6050 4340 -6050 {lab=B0B}
N 4280 -5770 4340 -5770 {lab=B0B}
N 4280 -5490 4340 -5490 {lab=B0B}
N 4280 -5210 4340 -5210 {lab=B0B}
N 4280 -4930 4340 -4930 {lab=B0B}
N 4280 -4650 4340 -4650 {lab=B0B}
N 4280 -4370 4340 -4370 {lab=B0B}
N 4280 -4090 4340 -4090 {lab=B0B}
N 4280 -3810 4340 -3810 {lab=B0B}
N 4280 -3530 4340 -3530 {lab=B0B}
N 4280 -3250 4340 -3250 {lab=B0B}
N 4280 -2970 4340 -2970 {lab=B0B}
N 4280 -2690 4340 -2690 {lab=B0B}
N 4280 -2410 4340 -2410 {lab=B0B}
N 4280 -2130 4340 -2130 {lab=B0B}
N 2300 -6250 2360 -6250 {lab=B1B}
N 2300 -6110 2360 -6110 {lab=B1B}
N 2300 -5690 2360 -5690 {lab=B1B}
N 2300 -5550 2360 -5550 {lab=B1B}
N 2300 -5130 2360 -5130 {lab=B1B}
N 2300 -4990 2360 -4990 {lab=B1B}
N 2300 -4570 2360 -4570 {lab=B1B}
N 2300 -4430 2360 -4430 {lab=B1B}
N 2300 -4010 2360 -4010 {lab=B1B}
N 2300 -3870 2360 -3870 {lab=B1B}
N 2300 -3450 2360 -3450 {lab=B1B}
N 2300 -3310 2360 -3310 {lab=B1B}
N 2300 -2890 2360 -2890 {lab=B1B}
N 2300 -2750 2360 -2750 {lab=B1B}
N 2300 -2330 2360 -2330 {lab=B1B}
N 2300 -2190 2360 -2190 {lab=B1B}
N 4080 -6190 4140 -6190 {lab=B1B}
N 4080 -6050 4140 -6050 {lab=B1B}
N 4080 -5630 4140 -5630 {lab=B1B}
N 4080 -5490 4140 -5490 {lab=B1B}
N 4080 -5070 4140 -5070 {lab=B1B}
N 4080 -4930 4140 -4930 {lab=B1B}
N 4080 -4510 4140 -4510 {lab=B1B}
N 4080 -4370 4140 -4370 {lab=B1B}
N 4080 -3950 4140 -3950 {lab=B1B}
N 4080 -3810 4140 -3810 {lab=B1B}
N 4080 -3390 4140 -3390 {lab=B1B}
N 4080 -3250 4140 -3250 {lab=B1B}
N 4080 -2830 4140 -2830 {lab=B1B}
N 4080 -2690 4140 -2690 {lab=B1B}
N 4080 -2270 4140 -2270 {lab=B1B}
N 4080 -2130 4140 -2130 {lab=B1B}
N 2100 -5970 2160 -5970 {lab=B2B}
N 2100 -5830 2160 -5830 {lab=B2B}
N 2100 -5690 2160 -5690 {lab=B2B}
N 2100 -5550 2160 -5550 {lab=B2B}
N 2100 -4850 2160 -4850 {lab=B2B}
N 2100 -4710 2160 -4710 {lab=B2B}
N 2100 -4570 2160 -4570 {lab=B2B}
N 2100 -4430 2160 -4430 {lab=B2B}
N 2100 -3730 2160 -3730 {lab=B2B}
N 2100 -3590 2160 -3590 {lab=B2B}
N 2100 -3450 2160 -3450 {lab=B2B}
N 2100 -3310 2160 -3310 {lab=B2B}
N 2100 -2610 2160 -2610 {lab=B2B}
N 2100 -2470 2160 -2470 {lab=B2B}
N 2100 -2330 2160 -2330 {lab=B2B}
N 2100 -2190 2160 -2190 {lab=B2B}
N 3880 -5910 3940 -5910 {lab=B2B}
N 3880 -5770 3940 -5770 {lab=B2B}
N 3880 -5630 3940 -5630 {lab=B2B}
N 3880 -5490 3940 -5490 {lab=B2B}
N 3880 -4790 3940 -4790 {lab=B2B}
N 3880 -4650 3940 -4650 {lab=B2B}
N 3880 -4510 3940 -4510 {lab=B2B}
N 3880 -4370 3940 -4370 {lab=B2B}
N 3880 -3670 3940 -3670 {lab=B2B}
N 3880 -3530 3940 -3530 {lab=B2B}
N 3880 -3390 3940 -3390 {lab=B2B}
N 3880 -3250 3940 -3250 {lab=B2B}
N 3880 -2550 3940 -2550 {lab=B2B}
N 3880 -2410 3940 -2410 {lab=B2B}
N 3880 -2270 3940 -2270 {lab=B2B}
N 3880 -2130 3940 -2130 {lab=B2B}
N 1900 -5410 1960 -5410 {lab=B3B}
N 1900 -5270 1960 -5270 {lab=B3B}
N 1900 -5130 1960 -5130 {lab=B3B}
N 1900 -4990 1960 -4990 {lab=B3B}
N 1900 -4850 1960 -4850 {lab=B3B}
N 1900 -4710 1960 -4710 {lab=B3B}
N 1900 -4570 1960 -4570 {lab=B3B}
N 1900 -4430 1960 -4430 {lab=B3B}
N 1900 -3170 1960 -3170 {lab=B3B}
N 1900 -3030 1960 -3030 {lab=B3B}
N 1900 -2890 1960 -2890 {lab=B3B}
N 1900 -2750 1960 -2750 {lab=B3B}
N 1900 -2610 1960 -2610 {lab=B3B}
N 1900 -2470 1960 -2470 {lab=B3B}
N 1900 -2330 1960 -2330 {lab=B3B}
N 1900 -2190 1960 -2190 {lab=B3B}
N 3680 -5350 3740 -5350 {lab=B3B}
N 3680 -5210 3740 -5210 {lab=B3B}
N 3680 -5070 3740 -5070 {lab=B3B}
N 3680 -4930 3740 -4930 {lab=B3B}
N 3680 -4790 3740 -4790 {lab=B3B}
N 3680 -4650 3740 -4650 {lab=B3B}
N 3680 -4510 3740 -4510 {lab=B3B}
N 3680 -4370 3740 -4370 {lab=B3B}
N 3680 -3110 3740 -3110 {lab=B3B}
N 3680 -2970 3740 -2970 {lab=B3B}
N 3680 -2830 3740 -2830 {lab=B3B}
N 3680 -2690 3740 -2690 {lab=B3B}
N 3680 -2550 3740 -2550 {lab=B3B}
N 3680 -2410 3740 -2410 {lab=B3B}
N 3680 -2270 3740 -2270 {lab=B3B}
N 3680 -2130 3740 -2130 {lab=B3B}
N 1700 -3170 1760 -3170 {lab=B4B}
N 1700 -3030 1760 -3030 {lab=B4B}
N 1700 -2890 1760 -2890 {lab=B4B}
N 1700 -2750 1760 -2750 {lab=B4B}
N 1700 -2610 1760 -2610 {lab=B4B}
N 1700 -2470 1760 -2470 {lab=B4B}
N 1700 -2330 1760 -2330 {lab=B4B}
N 1700 -2190 1760 -2190 {lab=B4B}
N 1700 -4290 1760 -4290 {lab=B4B}
N 1700 -4150 1760 -4150 {lab=B4B}
N 1700 -4010 1760 -4010 {lab=B4B}
N 1700 -3870 1760 -3870 {lab=B4B}
N 1700 -3730 1760 -3730 {lab=B4B}
N 1700 -3590 1760 -3590 {lab=B4B}
N 1700 -3450 1760 -3450 {lab=B4B}
N 1700 -3310 1760 -3310 {lab=B4B}
N 3480 -3110 3540 -3110 {lab=B4B}
N 3480 -2970 3540 -2970 {lab=B4B}
N 3480 -2830 3540 -2830 {lab=B4B}
N 3480 -2690 3540 -2690 {lab=B4B}
N 3480 -2550 3540 -2550 {lab=B4B}
N 3480 -2410 3540 -2410 {lab=B4B}
N 3480 -2270 3540 -2270 {lab=B4B}
N 3480 -2130 3540 -2130 {lab=B4B}
N 3480 -4230 3540 -4230 {lab=B4B}
N 3480 -4090 3540 -4090 {lab=B4B}
N 3480 -3950 3540 -3950 {lab=B4B}
N 3480 -3810 3540 -3810 {lab=B4B}
N 3480 -3670 3540 -3670 {lab=B4B}
N 3480 -3530 3540 -3530 {lab=B4B}
N 3480 -3390 3540 -3390 {lab=B4B}
N 3480 -3250 3540 -3250 {lab=B4B}
N 2300 -6790 2300 -6770 {lab=VDD}
N 2100 -6790 2100 -6770 {lab=VDD}
N 1900 -6790 1900 -6770 {lab=VDD}
N 1700 -6790 1700 -6770 {lab=VDD}
N 970 -6360 2460 -6360 {lab=IN0}
N 970 -6220 2260 -6220 {lab=IN1}
N 2460 -6140 2460 -6080 {lab=IN2}
N 2260 -6140 2260 -6080 {lab=IN2}
N 970 -6140 2460 -6140 {lab=IN2}
N 2060 -6000 2060 -5940 {lab=IN3}
N 2060 -5860 2060 -5800 {lab=IN4}
N 2060 -5720 2060 -5660 {lab=IN5}
N 2060 -5580 2060 -5520 {lab=IN6}
N 2060 -4880 2060 -4820 {lab=IN11}
N 2060 -4740 2060 -4680 {lab=IN12}
N 2060 -4600 2060 -4540 {lab=IN13}
N 2060 -4460 2060 -4400 {lab=IN14}
N 2060 -3760 2060 -3700 {lab=IN19}
N 2060 -3620 2060 -3560 {lab=IN20}
N 2060 -3480 2060 -3420 {lab=IN21}
N 2060 -3340 2060 -3280 {lab=IN22}
N 2060 -2640 2060 -2580 {lab=IN27}
N 2060 -2500 2060 -2440 {lab=IN28}
N 2060 -2360 2060 -2300 {lab=IN29}
N 2060 -2220 2060 -2160 {lab=IN30}
N 3840 -5940 3840 -5880 {lab=IN35}
N 3840 -5800 3840 -5740 {lab=IN36}
N 3840 -5660 3840 -5600 {lab=IN37}
N 3840 -5520 3840 -5460 {lab=IN38}
N 3840 -4820 3840 -4760 {lab=IN43}
N 3840 -4680 3840 -4620 {lab=IN44}
N 3840 -4540 3840 -4480 {lab=IN45}
N 3840 -4400 3840 -4340 {lab=IN46}
N 3840 -3700 3840 -3640 {lab=IN51}
N 3840 -3560 3840 -3500 {lab=IN52}
N 3840 -3420 3840 -3360 {lab=IN53}
N 3840 -3280 3840 -3220 {lab=IN54}
N 3840 -2580 3840 -2520 {lab=IN59}
N 3840 -2440 3840 -2380 {lab=IN60}
N 3840 -2300 3840 -2240 {lab=IN61}
N 3840 -2160 3840 -2100 {lab=IN62}
N 3640 -2580 3640 -2520 {lab=IN59}
N 3640 -2440 3640 -2380 {lab=IN60}
N 3640 -2300 3640 -2240 {lab=IN61}
N 3640 -2160 3640 -2100 {lab=IN62}
N 3640 -3140 3640 -3080 {lab=IN55}
N 3640 -3000 3640 -2940 {lab=IN56}
N 3640 -2860 3640 -2800 {lab=IN57}
N 3640 -2720 3640 -2660 {lab=IN58}
N 3640 -4820 3640 -4760 {lab=IN43}
N 3640 -4680 3640 -4620 {lab=IN44}
N 3640 -4540 3640 -4480 {lab=IN45}
N 3640 -4400 3640 -4340 {lab=IN46}
N 3640 -5380 3640 -5320 {lab=IN39}
N 3640 -5240 3640 -5180 {lab=IN40}
N 3640 -5100 3640 -5040 {lab=IN41}
N 3640 -4960 3640 -4900 {lab=IN42}
N 2460 -5860 2460 -5800 {lab=IN4}
N 2460 -5580 2460 -5520 {lab=IN6}
N 2460 -5300 2460 -5240 {lab=IN8}
N 2460 -5020 2460 -4960 {lab=IN10}
N 2460 -4740 2460 -4680 {lab=IN12}
N 2460 -4460 2460 -4400 {lab=IN14}
N 2460 -4180 2460 -4120 {lab=IN16}
N 2460 -3900 2460 -3840 {lab=IN18}
N 2460 -3620 2460 -3560 {lab=IN20}
N 2460 -3340 2460 -3280 {lab=IN22}
N 2460 -3060 2460 -3000 {lab=IN24}
N 2460 -2780 2460 -2720 {lab=IN26}
N 2460 -2500 2460 -2440 {lab=IN28}
N 2460 -2220 2460 -2160 {lab=IN30}
N 4240 -6360 4240 -6300 {lab=IN32}
N 4240 -6080 4240 -6020 {lab=IN34}
N 4240 -5800 4240 -5740 {lab=IN36}
N 4240 -5520 4240 -5460 {lab=IN38}
N 4240 -5240 4240 -5180 {lab=IN40}
N 4240 -4960 4240 -4900 {lab=IN42}
N 4240 -4680 4240 -4620 {lab=IN44}
N 4240 -4400 4240 -4340 {lab=IN46}
N 4240 -4120 4240 -4060 {lab=IN48}
N 4240 -3840 4240 -3780 {lab=IN50}
N 4240 -3560 4240 -3500 {lab=IN52}
N 4240 -3280 4240 -3220 {lab=IN54}
N 4240 -3000 4240 -2940 {lab=IN56}
N 4240 -2720 4240 -2660 {lab=IN58}
N 4240 -2440 4240 -2380 {lab=IN60}
N 4240 -2160 4240 -2100 {lab=IN62}
N 1860 -2640 1860 -2580 {lab=IN27}
N 1860 -2500 1860 -2440 {lab=IN28}
N 1860 -2360 1860 -2300 {lab=IN29}
N 1860 -2220 1860 -2160 {lab=IN30}
N 1860 -3200 1860 -3140 {lab=IN23}
N 1860 -3060 1860 -3000 {lab=IN24}
N 1860 -2920 1860 -2860 {lab=IN25}
N 1860 -2780 1860 -2720 {lab=IN26}
N 1860 -4880 1860 -4820 {lab=IN11}
N 1860 -4740 1860 -4680 {lab=IN12}
N 1860 -4600 1860 -4540 {lab=IN13}
N 1860 -4460 1860 -4400 {lab=IN14}
N 1860 -5440 1860 -5380 {lab=IN7}
N 1860 -5300 1860 -5240 {lab=IN8}
N 1860 -5160 1860 -5100 {lab=IN9}
N 1860 -5020 1860 -4960 {lab=IN10}
N 1660 -3760 1660 -3700 {lab=IN19}
N 1660 -3620 1660 -3560 {lab=IN20}
N 1660 -3480 1660 -3420 {lab=IN21}
N 1660 -3340 1660 -3280 {lab=IN22}
N 1660 -4320 1660 -4260 {lab=IN15}
N 1660 -4180 1660 -4120 {lab=IN16}
N 1660 -4040 1660 -3980 {lab=IN17}
N 1660 -3900 1660 -3840 {lab=IN18}
N 1660 -2640 1660 -2580 {lab=IN27}
N 1660 -2500 1660 -2440 {lab=IN28}
N 1660 -2360 1660 -2300 {lab=IN29}
N 1660 -2220 1660 -2160 {lab=IN30}
N 1660 -3200 1660 -3140 {lab=IN23}
N 1660 -3060 1660 -3000 {lab=IN24}
N 1660 -2920 1660 -2860 {lab=IN25}
N 1660 -2780 1660 -2720 {lab=IN26}
N 3440 -3700 3440 -3640 {lab=IN51}
N 3440 -3560 3440 -3500 {lab=IN52}
N 3440 -3420 3440 -3360 {lab=IN53}
N 3440 -3280 3440 -3220 {lab=IN54}
N 3440 -4260 3440 -4200 {lab=IN47}
N 3440 -4120 3440 -4060 {lab=IN48}
N 3440 -3980 3440 -3920 {lab=IN49}
N 3440 -3840 3440 -3780 {lab=IN50}
N 3440 -2580 3440 -2520 {lab=IN59}
N 3440 -2440 3440 -2380 {lab=IN60}
N 3440 -2300 3440 -2240 {lab=IN61}
N 3440 -2160 3440 -2100 {lab=IN62}
N 3440 -3140 3440 -3080 {lab=IN55}
N 3440 -3000 3440 -2940 {lab=IN56}
N 3440 -2860 3440 -2800 {lab=IN57}
N 3440 -2720 3440 -2660 {lab=IN58}
N 4040 -4540 4040 -4480 {lab=IN45}
N 4040 -4400 4040 -4340 {lab=IN46}
N 4040 -5100 4040 -5040 {lab=IN41}
N 4040 -4960 4040 -4900 {lab=IN42}
N 4040 -5660 4040 -5600 {lab=IN37}
N 4040 -5520 4040 -5460 {lab=IN38}
N 2260 -2360 2260 -2300 {lab=IN29}
N 2260 -2220 2260 -2160 {lab=IN30}
N 2260 -2920 2260 -2860 {lab=IN25}
N 2260 -2780 2260 -2720 {lab=IN26}
N 2260 -3480 2260 -3420 {lab=IN21}
N 2260 -3340 2260 -3280 {lab=IN22}
N 2260 -4040 2260 -3980 {lab=IN17}
N 2260 -3900 2260 -3840 {lab=IN18}
N 2260 -4600 2260 -4540 {lab=IN13}
N 2260 -4460 2260 -4400 {lab=IN14}
N 2260 -5160 2260 -5100 {lab=IN9}
N 2260 -5020 2260 -4960 {lab=IN10}
N 4040 -2300 4040 -2240 {lab=IN61}
N 4040 -2160 4040 -2100 {lab=IN62}
N 4040 -2860 4040 -2800 {lab=IN57}
N 4040 -2720 4040 -2660 {lab=IN58}
N 4040 -3420 4040 -3360 {lab=IN53}
N 4040 -3280 4040 -3220 {lab=IN54}
N 4040 -3980 4040 -3920 {lab=IN49}
N 4040 -3840 4040 -3780 {lab=IN50}
N 4040 -6220 4040 -6160 {lab=IN33}
N 4040 -6080 4040 -6020 {lab=IN34}
N 2260 -5720 2260 -5660 {lab=IN5}
N 2260 -5580 2260 -5520 {lab=IN6}
N 960 -6000 2450 -6000 {lab=IN3}
N 970 -5860 2460 -5860 {lab=IN4}
N 970 -5720 2460 -5720 {lab=IN5}
N 970 -5580 2460 -5580 {lab=IN6}
N 980 -5440 2470 -5440 {lab=IN7}
N 980 -5300 2470 -5300 {lab=IN8}
N 970 -5160 2460 -5160 {lab=IN9}
N 980 -5020 2470 -5020 {lab=IN10}
N 980 -4880 2470 -4880 {lab=IN11}
N 970 -4740 2460 -4740 {lab=IN12}
N 980 -4600 2470 -4600 {lab=IN13}
N 980 -4460 2470 -4460 {lab=IN14}
N 960 -4320 2450 -4320 {lab=IN15}
N 970 -4180 2460 -4180 {lab=IN16}
N 970 -4040 2460 -4040 {lab=IN17}
N 970 -3900 2460 -3900 {lab=IN18}
N 980 -3760 2470 -3760 {lab=IN19}
N 980 -3620 2470 -3620 {lab=IN20}
N 960 -3480 2450 -3480 {lab=IN21}
N 970 -3340 2460 -3340 {lab=IN22}
N 970 -3200 2460 -3200 {lab=IN23}
N 970 -3060 2460 -3060 {lab=IN24}
N 970 -2920 2460 -2920 {lab=IN25}
N 980 -2780 2470 -2780 {lab=IN26}
N 980 -2640 2470 -2640 {lab=IN27}
N 970 -2500 2460 -2500 {lab=IN28}
N 980 -2360 2470 -2360 {lab=IN29}
N 980 -2220 2470 -2220 {lab=IN30}
N 2760 -6360 4250 -6360 {lab=IN32}
N 2760 -6220 4250 -6220 {lab=IN33}
N 2740 -6080 4230 -6080 {lab=IN34}
N 2750 -5940 4240 -5940 {lab=IN35}
N 2750 -5800 4240 -5800 {lab=IN36}
N 2750 -5660 4240 -5660 {lab=IN37}
N 2760 -5520 4250 -5520 {lab=IN38}
N 2760 -5380 4250 -5380 {lab=IN39}
N 2740 -5240 4230 -5240 {lab=IN40}
N 2750 -5100 4240 -5100 {lab=IN41}
N 2750 -4960 4240 -4960 {lab=IN42}
N 2750 -4820 4240 -4820 {lab=IN43}
N 2750 -4680 4240 -4680 {lab=IN44}
N 2760 -4540 4250 -4540 {lab=IN45}
N 2760 -4400 4250 -4400 {lab=IN46}
N 2750 -4260 4240 -4260 {lab=IN47}
N 2760 -4120 4250 -4120 {lab=IN48}
N 2760 -3980 4250 -3980 {lab=IN49}
N 2750 -3840 4240 -3840 {lab=IN50}
N 2760 -3700 4250 -3700 {lab=IN51}
N 2760 -3560 4250 -3560 {lab=IN52}
N 2740 -3420 4230 -3420 {lab=IN53}
N 2750 -3280 4240 -3280 {lab=IN54}
N 2750 -3140 4240 -3140 {lab=IN55}
N 2750 -3000 4240 -3000 {lab=IN56}
N 2760 -2860 4250 -2860 {lab=IN57}
N 2760 -2720 4250 -2720 {lab=IN58}
N 2740 -2580 4230 -2580 {lab=IN59}
N 2750 -2440 4240 -2440 {lab=IN60}
N 2750 -2300 4240 -2300 {lab=IN61}
N 2750 -2160 4240 -2160 {lab=IN62}
N 2500 -2190 2560 -2190 {lab=B0B}
N 4230 -6080 4240 -6080 {lab=IN34}
N 4230 -5240 4240 -5240 {lab=IN40}
N 1240 -1810 1240 -1730 {lab=B5}
N 1240 -1810 1310 -1810 {lab=B5}
N 1240 -1730 1240 -1660 {lab=B5}
N 1240 -1660 1310 -1660 {lab=B5}
N 1350 -1780 1350 -1690 {lab=CBAR}
N 1350 -1730 1460 -1730 {lab=CBAR}
N 1350 -1630 1350 -1610 {lab=GND}
N 1350 -1860 1350 -1840 {lab=VDD}
N 1200 -1730 1240 -1730 {lab=B5}
N 1345 -1810 1360 -1810 {lab=VDD}
N 1350 -1660 1370 -1660 {lab=GND}
N 1910 -1820 1910 -1740 {lab=B3bar}
N 1910 -1820 1980 -1820 {lab=B3bar}
N 1910 -1740 1910 -1670 {lab=B3bar}
N 1910 -1670 1980 -1670 {lab=B3bar}
N 2020 -1790 2020 -1700 {lab=B3}
N 2020 -1740 2130 -1740 {lab=B3}
N 2020 -1640 2020 -1620 {lab=GND}
N 2020 -1870 2020 -1850 {lab=VDD}
N 1870 -1740 1910 -1740 {lab=B3bar}
N 2015 -1820 2030 -1820 {lab=VDD}
N 2020 -1670 2040 -1670 {lab=GND}
N 1700 -6850 1760 -6850 {lab=VDD}
N 1700 -6850 1700 -6790 {lab=VDD}
N 1900 -6850 1960 -6850 {lab=VDD}
N 1900 -6850 1900 -6790 {lab=VDD}
N 2100 -6850 2160 -6850 {lab=VDD}
N 2100 -6850 2100 -6790 {lab=VDD}
N 2300 -6850 2360 -6850 {lab=VDD}
N 2300 -6850 2300 -6790 {lab=VDD}
N 2500 -6850 2560 -6850 {lab=VDD}
N 2500 -6850 2500 -6790 {lab=VDD}
N 1760 -6450 1760 -2190 {lab=B4B}
N 1960 -6450 1960 -2190 {lab=B3B}
N 2160 -6450 2160 -2190 {lab=B2B}
N 2360 -6450 2360 -2190 {lab=B1B}
N 2560 -6450 2560 -2190 {lab=B0B}
N 4340 -6360 4340 -2100 {lab=B0B}
N 4140 -6350 4140 -2090 {lab=B1B}
N 3940 -6380 3940 -2120 {lab=B2B}
N 3740 -6390 3740 -2130 {lab=B3B}
N 3540 -6380 3540 -2120 {lab=B4B}
N 2500 -6790 2500 -6770 {lab=VDD}
N 2500 -6330 2500 -6310 {lab=GND}
N 2500 -6360 2520 -6360 {lab=GND}
N 2500 -6050 2500 -6030 {lab=GND}
N 2500 -6080 2520 -6080 {lab=GND}
N 2500 -5770 2500 -5750 {lab=GND}
N 2500 -5800 2520 -5800 {lab=GND}
N 2300 -6050 2300 -6030 {lab=GND}
N 2300 -6080 2320 -6080 {lab=GND}
N 2300 -6190 2300 -6170 {lab=GND}
N 2300 -6220 2320 -6220 {lab=GND}
N 2300 -5630 2300 -5610 {lab=GND}
N 2300 -5660 2320 -5660 {lab=GND}
N 2500 -5490 2500 -5470 {lab=GND}
N 2500 -5520 2520 -5520 {lab=GND}
N 2300 -5490 2300 -5470 {lab=GND}
N 2300 -5520 2320 -5520 {lab=GND}
N 2100 -5770 2100 -5750 {lab=GND}
N 2100 -5800 2120 -5800 {lab=GND}
N 2100 -5910 2100 -5890 {lab=GND}
N 2100 -5940 2120 -5940 {lab=GND}
N 2100 -5490 2100 -5470 {lab=GND}
N 2100 -5520 2120 -5520 {lab=GND}
N 2100 -5630 2100 -5610 {lab=GND}
N 2100 -5660 2120 -5660 {lab=GND}
N 2500 -5210 2500 -5190 {lab=GND}
N 2500 -5240 2520 -5240 {lab=GND}
N 2500 -4930 2500 -4910 {lab=GND}
N 2500 -4960 2520 -4960 {lab=GND}
N 2500 -4650 2500 -4630 {lab=GND}
N 2500 -4680 2520 -4680 {lab=GND}
N 2300 -4930 2300 -4910 {lab=GND}
N 2300 -4960 2320 -4960 {lab=GND}
N 2300 -5070 2300 -5050 {lab=GND}
N 2300 -5100 2320 -5100 {lab=GND}
N 2300 -4510 2300 -4490 {lab=GND}
N 2300 -4540 2320 -4540 {lab=GND}
N 2500 -4370 2500 -4350 {lab=GND}
N 2500 -4400 2520 -4400 {lab=GND}
N 2300 -4370 2300 -4350 {lab=GND}
N 2300 -4400 2320 -4400 {lab=GND}
N 2100 -4650 2100 -4630 {lab=GND}
N 2100 -4680 2120 -4680 {lab=GND}
N 2100 -4790 2100 -4770 {lab=GND}
N 2100 -4820 2120 -4820 {lab=GND}
N 2100 -4370 2100 -4350 {lab=GND}
N 2100 -4400 2120 -4400 {lab=GND}
N 2100 -4510 2100 -4490 {lab=GND}
N 2100 -4540 2120 -4540 {lab=GND}
N 1900 -5210 1900 -5190 {lab=GND}
N 1900 -5240 1920 -5240 {lab=GND}
N 1900 -5350 1900 -5330 {lab=GND}
N 1900 -5380 1920 -5380 {lab=GND}
N 1900 -4930 1900 -4910 {lab=GND}
N 1900 -4960 1920 -4960 {lab=GND}
N 1900 -5070 1900 -5050 {lab=GND}
N 1900 -5100 1920 -5100 {lab=GND}
N 1900 -4650 1900 -4630 {lab=GND}
N 1900 -4680 1920 -4680 {lab=GND}
N 1900 -4790 1900 -4770 {lab=GND}
N 1900 -4820 1920 -4820 {lab=GND}
N 1900 -4370 1900 -4350 {lab=GND}
N 1900 -4400 1920 -4400 {lab=GND}
N 1900 -4510 1900 -4490 {lab=GND}
N 1900 -4540 1920 -4540 {lab=GND}
N 1700 -4230 1700 -4210 {lab=GND}
N 1700 -4260 1720 -4260 {lab=GND}
N 2500 -4090 2500 -4070 {lab=GND}
N 2500 -4120 2520 -4120 {lab=GND}
N 2500 -3810 2500 -3790 {lab=GND}
N 2500 -3840 2520 -3840 {lab=GND}
N 2500 -3530 2500 -3510 {lab=GND}
N 2500 -3560 2520 -3560 {lab=GND}
N 2300 -3810 2300 -3790 {lab=GND}
N 2300 -3840 2320 -3840 {lab=GND}
N 2300 -3950 2300 -3930 {lab=GND}
N 2300 -3980 2320 -3980 {lab=GND}
N 2300 -3390 2300 -3370 {lab=GND}
N 2300 -3420 2320 -3420 {lab=GND}
N 2500 -3250 2500 -3230 {lab=GND}
N 2500 -3280 2520 -3280 {lab=GND}
N 2300 -3250 2300 -3230 {lab=GND}
N 2300 -3280 2320 -3280 {lab=GND}
N 2100 -3530 2100 -3510 {lab=GND}
N 2100 -3560 2120 -3560 {lab=GND}
N 2100 -3670 2100 -3650 {lab=GND}
N 2100 -3700 2120 -3700 {lab=GND}
N 2100 -3250 2100 -3230 {lab=GND}
N 2100 -3280 2120 -3280 {lab=GND}
N 2100 -3390 2100 -3370 {lab=GND}
N 2100 -3420 2120 -3420 {lab=GND}
N 2500 -2970 2500 -2950 {lab=GND}
N 2500 -3000 2520 -3000 {lab=GND}
N 2500 -2690 2500 -2670 {lab=GND}
N 2500 -2720 2520 -2720 {lab=GND}
N 2500 -2410 2500 -2390 {lab=GND}
N 2500 -2440 2520 -2440 {lab=GND}
N 2300 -2690 2300 -2670 {lab=GND}
N 2300 -2720 2320 -2720 {lab=GND}
N 2300 -2830 2300 -2810 {lab=GND}
N 2300 -2860 2320 -2860 {lab=GND}
N 2300 -2270 2300 -2250 {lab=GND}
N 2300 -2300 2320 -2300 {lab=GND}
N 2500 -2130 2500 -2110 {lab=GND}
N 2500 -2160 2520 -2160 {lab=GND}
N 2300 -2130 2300 -2110 {lab=GND}
N 2300 -2160 2320 -2160 {lab=GND}
N 2100 -2410 2100 -2390 {lab=GND}
N 2100 -2440 2120 -2440 {lab=GND}
N 2100 -2550 2100 -2530 {lab=GND}
N 2100 -2580 2120 -2580 {lab=GND}
N 2100 -2130 2100 -2110 {lab=GND}
N 2100 -2160 2120 -2160 {lab=GND}
N 2100 -2270 2100 -2250 {lab=GND}
N 2100 -2300 2120 -2300 {lab=GND}
N 1900 -2970 1900 -2950 {lab=GND}
N 1900 -3000 1920 -3000 {lab=GND}
N 1900 -3110 1900 -3090 {lab=GND}
N 1900 -3140 1920 -3140 {lab=GND}
N 1900 -2690 1900 -2670 {lab=GND}
N 1900 -2720 1920 -2720 {lab=GND}
N 1900 -2830 1900 -2810 {lab=GND}
N 1900 -2860 1920 -2860 {lab=GND}
N 1900 -2410 1900 -2390 {lab=GND}
N 1900 -2440 1920 -2440 {lab=GND}
N 1900 -2550 1900 -2530 {lab=GND}
N 1900 -2580 1920 -2580 {lab=GND}
N 1900 -2130 1900 -2110 {lab=GND}
N 1900 -2160 1920 -2160 {lab=GND}
N 1900 -2270 1900 -2250 {lab=GND}
N 1900 -2300 1920 -2300 {lab=GND}
N 1700 -3950 1700 -3930 {lab=GND}
N 1700 -3980 1720 -3980 {lab=GND}
N 1700 -4090 1700 -4070 {lab=GND}
N 1700 -4120 1720 -4120 {lab=GND}
N 1700 -3670 1700 -3650 {lab=GND}
N 1700 -3700 1720 -3700 {lab=GND}
N 1700 -3810 1700 -3790 {lab=GND}
N 1700 -3840 1720 -3840 {lab=GND}
N 1700 -3390 1700 -3370 {lab=GND}
N 1700 -3420 1720 -3420 {lab=GND}
N 1700 -3530 1700 -3510 {lab=GND}
N 1700 -3560 1720 -3560 {lab=GND}
N 1700 -3250 1700 -3230 {lab=GND}
N 1700 -3280 1720 -3280 {lab=GND}
N 1700 -3110 1700 -3090 {lab=GND}
N 1700 -3140 1720 -3140 {lab=GND}
N 1700 -2830 1700 -2810 {lab=GND}
N 1700 -2860 1720 -2860 {lab=GND}
N 1700 -2970 1700 -2950 {lab=GND}
N 1700 -3000 1720 -3000 {lab=GND}
N 1700 -2550 1700 -2530 {lab=GND}
N 1700 -2580 1720 -2580 {lab=GND}
N 1700 -2690 1700 -2670 {lab=GND}
N 1700 -2720 1720 -2720 {lab=GND}
N 1700 -2270 1700 -2250 {lab=GND}
N 1700 -2300 1720 -2300 {lab=GND}
N 1700 -2410 1700 -2390 {lab=GND}
N 1700 -2440 1720 -2440 {lab=GND}
N 1700 -2130 1700 -2110 {lab=GND}
N 1700 -2160 1720 -2160 {lab=GND}
N 2500 -6390 2560 -6390 {lab=B0B}
N 2500 -6110 2560 -6110 {lab=B0B}
N 2500 -5830 2560 -5830 {lab=B0B}
N 2500 -5550 2560 -5550 {lab=B0B}
N 2500 -5270 2560 -5270 {lab=B0B}
N 2500 -4990 2560 -4990 {lab=B0B}
N 2500 -4710 2560 -4710 {lab=B0B}
N 2500 -4430 2560 -4430 {lab=B0B}
N 2500 -4150 2560 -4150 {lab=B0B}
N 2500 -3870 2560 -3870 {lab=B0B}
N 2500 -3590 2560 -3590 {lab=B0B}
N 2500 -3310 2560 -3310 {lab=B0B}
N 2500 -3030 2560 -3030 {lab=B0B}
N 2500 -2750 2560 -2750 {lab=B0B}
N 2500 -2470 2560 -2470 {lab=B0B}
N 2300 -6250 2360 -6250 {lab=B1B}
N 2300 -6110 2360 -6110 {lab=B1B}
N 2300 -5690 2360 -5690 {lab=B1B}
N 2300 -5550 2360 -5550 {lab=B1B}
N 2300 -5130 2360 -5130 {lab=B1B}
N 2300 -4990 2360 -4990 {lab=B1B}
N 2300 -4570 2360 -4570 {lab=B1B}
N 2300 -4430 2360 -4430 {lab=B1B}
N 2300 -4010 2360 -4010 {lab=B1B}
N 2300 -3870 2360 -3870 {lab=B1B}
N 2300 -3450 2360 -3450 {lab=B1B}
N 2300 -3310 2360 -3310 {lab=B1B}
N 2300 -2890 2360 -2890 {lab=B1B}
N 2300 -2750 2360 -2750 {lab=B1B}
N 2300 -2330 2360 -2330 {lab=B1B}
N 2300 -2190 2360 -2190 {lab=B1B}
N 2100 -5970 2160 -5970 {lab=B2B}
N 2100 -5830 2160 -5830 {lab=B2B}
N 2100 -5690 2160 -5690 {lab=B2B}
N 2100 -5550 2160 -5550 {lab=B2B}
N 2100 -4850 2160 -4850 {lab=B2B}
N 2100 -4710 2160 -4710 {lab=B2B}
N 2100 -4570 2160 -4570 {lab=B2B}
N 2100 -4430 2160 -4430 {lab=B2B}
N 2100 -3730 2160 -3730 {lab=B2B}
N 2100 -3590 2160 -3590 {lab=B2B}
N 2100 -3450 2160 -3450 {lab=B2B}
N 2100 -3310 2160 -3310 {lab=B2B}
N 2100 -2610 2160 -2610 {lab=B2B}
N 2100 -2470 2160 -2470 {lab=B2B}
N 2100 -2330 2160 -2330 {lab=B2B}
N 2100 -2190 2160 -2190 {lab=B2B}
N 1900 -5410 1960 -5410 {lab=B3B}
N 1900 -5270 1960 -5270 {lab=B3B}
N 1900 -5130 1960 -5130 {lab=B3B}
N 1900 -4990 1960 -4990 {lab=B3B}
N 1900 -4850 1960 -4850 {lab=B3B}
N 1900 -4710 1960 -4710 {lab=B3B}
N 1900 -4570 1960 -4570 {lab=B3B}
N 1900 -4430 1960 -4430 {lab=B3B}
N 1900 -3170 1960 -3170 {lab=B3B}
N 1900 -3030 1960 -3030 {lab=B3B}
N 1900 -2890 1960 -2890 {lab=B3B}
N 1900 -2750 1960 -2750 {lab=B3B}
N 1900 -2610 1960 -2610 {lab=B3B}
N 1900 -2470 1960 -2470 {lab=B3B}
N 1900 -2330 1960 -2330 {lab=B3B}
N 1900 -2190 1960 -2190 {lab=B3B}
N 1700 -3170 1760 -3170 {lab=B4B}
N 1700 -3030 1760 -3030 {lab=B4B}
N 1700 -2890 1760 -2890 {lab=B4B}
N 1700 -2750 1760 -2750 {lab=B4B}
N 1700 -2610 1760 -2610 {lab=B4B}
N 1700 -2470 1760 -2470 {lab=B4B}
N 1700 -2330 1760 -2330 {lab=B4B}
N 1700 -2190 1760 -2190 {lab=B4B}
N 1700 -4290 1760 -4290 {lab=B4B}
N 1700 -4150 1760 -4150 {lab=B4B}
N 1700 -4010 1760 -4010 {lab=B4B}
N 1700 -3870 1760 -3870 {lab=B4B}
N 1700 -3730 1760 -3730 {lab=B4B}
N 1700 -3590 1760 -3590 {lab=B4B}
N 1700 -3450 1760 -3450 {lab=B4B}
N 1700 -3310 1760 -3310 {lab=B4B}
N 2300 -6790 2300 -6770 {lab=VDD}
N 2100 -6790 2100 -6770 {lab=VDD}
N 1900 -6790 1900 -6770 {lab=VDD}
N 1700 -6790 1700 -6770 {lab=VDD}
N 970 -6360 2460 -6360 {lab=IN0}
N 970 -6220 2260 -6220 {lab=IN1}
N 2460 -6140 2460 -6080 {lab=IN2}
N 2260 -6140 2260 -6080 {lab=IN2}
N 970 -6140 2460 -6140 {lab=IN2}
N 2060 -6000 2060 -5940 {lab=IN3}
N 2060 -5860 2060 -5800 {lab=IN4}
N 2060 -5720 2060 -5660 {lab=IN5}
N 2060 -5580 2060 -5520 {lab=IN6}
N 2060 -4880 2060 -4820 {lab=IN11}
N 2060 -4740 2060 -4680 {lab=IN12}
N 2060 -4600 2060 -4540 {lab=IN13}
N 2060 -4460 2060 -4400 {lab=IN14}
N 2060 -3760 2060 -3700 {lab=IN19}
N 2060 -3620 2060 -3560 {lab=IN20}
N 2060 -3480 2060 -3420 {lab=IN21}
N 2060 -3340 2060 -3280 {lab=IN22}
N 2060 -2640 2060 -2580 {lab=IN27}
N 2060 -2500 2060 -2440 {lab=IN28}
N 2060 -2360 2060 -2300 {lab=IN29}
N 2060 -2220 2060 -2160 {lab=IN30}
N 2460 -5860 2460 -5800 {lab=IN4}
N 2460 -5580 2460 -5520 {lab=IN6}
N 2460 -5300 2460 -5240 {lab=IN8}
N 2460 -5020 2460 -4960 {lab=IN10}
N 2460 -4740 2460 -4680 {lab=IN12}
N 2460 -4460 2460 -4400 {lab=IN14}
N 2460 -4180 2460 -4120 {lab=IN16}
N 2460 -3900 2460 -3840 {lab=IN18}
N 2460 -3620 2460 -3560 {lab=IN20}
N 2460 -3340 2460 -3280 {lab=IN22}
N 2460 -3060 2460 -3000 {lab=IN24}
N 2460 -2780 2460 -2720 {lab=IN26}
N 2460 -2500 2460 -2440 {lab=IN28}
N 2460 -2220 2460 -2160 {lab=IN30}
N 1860 -2640 1860 -2580 {lab=IN27}
N 1860 -2500 1860 -2440 {lab=IN28}
N 1860 -2360 1860 -2300 {lab=IN29}
N 1860 -2220 1860 -2160 {lab=IN30}
N 1860 -3200 1860 -3140 {lab=IN23}
N 1860 -3060 1860 -3000 {lab=IN24}
N 1860 -2920 1860 -2860 {lab=IN25}
N 1860 -2780 1860 -2720 {lab=IN26}
N 1860 -4880 1860 -4820 {lab=IN11}
N 1860 -4740 1860 -4680 {lab=IN12}
N 1860 -4600 1860 -4540 {lab=IN13}
N 1860 -4460 1860 -4400 {lab=IN14}
N 1860 -5440 1860 -5380 {lab=IN7}
N 1860 -5300 1860 -5240 {lab=IN8}
N 1860 -5160 1860 -5100 {lab=IN9}
N 1860 -5020 1860 -4960 {lab=IN10}
N 1660 -3760 1660 -3700 {lab=IN19}
N 1660 -3620 1660 -3560 {lab=IN20}
N 1660 -3480 1660 -3420 {lab=IN21}
N 1660 -3340 1660 -3280 {lab=IN22}
N 1660 -4320 1660 -4260 {lab=IN15}
N 1660 -4180 1660 -4120 {lab=IN16}
N 1660 -4040 1660 -3980 {lab=IN17}
N 1660 -3900 1660 -3840 {lab=IN18}
N 1660 -2640 1660 -2580 {lab=IN27}
N 1660 -2500 1660 -2440 {lab=IN28}
N 1660 -2360 1660 -2300 {lab=IN29}
N 1660 -2220 1660 -2160 {lab=IN30}
N 1660 -3200 1660 -3140 {lab=IN23}
N 1660 -3060 1660 -3000 {lab=IN24}
N 1660 -2920 1660 -2860 {lab=IN25}
N 1660 -2780 1660 -2720 {lab=IN26}
N 2260 -2360 2260 -2300 {lab=IN29}
N 2260 -2220 2260 -2160 {lab=IN30}
N 2260 -2920 2260 -2860 {lab=IN25}
N 2260 -2780 2260 -2720 {lab=IN26}
N 2260 -3480 2260 -3420 {lab=IN21}
N 2260 -3340 2260 -3280 {lab=IN22}
N 2260 -4040 2260 -3980 {lab=IN17}
N 2260 -3900 2260 -3840 {lab=IN18}
N 2260 -4600 2260 -4540 {lab=IN13}
N 2260 -4460 2260 -4400 {lab=IN14}
N 2260 -5160 2260 -5100 {lab=IN9}
N 2260 -5020 2260 -4960 {lab=IN10}
N 2260 -5720 2260 -5660 {lab=IN5}
N 2260 -5580 2260 -5520 {lab=IN6}
N 960 -6000 2450 -6000 {lab=IN3}
N 970 -5860 2460 -5860 {lab=IN4}
N 970 -5720 2460 -5720 {lab=IN5}
N 970 -5580 2460 -5580 {lab=IN6}
N 980 -5440 2470 -5440 {lab=IN7}
N 980 -5300 2470 -5300 {lab=IN8}
N 970 -5160 2460 -5160 {lab=IN9}
N 980 -5020 2470 -5020 {lab=IN10}
N 980 -4880 2470 -4880 {lab=IN11}
N 970 -4740 2460 -4740 {lab=IN12}
N 980 -4600 2470 -4600 {lab=IN13}
N 980 -4460 2470 -4460 {lab=IN14}
N 960 -4320 2450 -4320 {lab=IN15}
N 970 -4180 2460 -4180 {lab=IN16}
N 970 -4040 2460 -4040 {lab=IN17}
N 970 -3900 2460 -3900 {lab=IN18}
N 980 -3760 2470 -3760 {lab=IN19}
N 980 -3620 2470 -3620 {lab=IN20}
N 960 -3480 2450 -3480 {lab=IN21}
N 970 -3340 2460 -3340 {lab=IN22}
N 970 -3200 2460 -3200 {lab=IN23}
N 970 -3060 2460 -3060 {lab=IN24}
N 970 -2920 2460 -2920 {lab=IN25}
N 980 -2780 2470 -2780 {lab=IN26}
N 980 -2640 2470 -2640 {lab=IN27}
N 970 -2500 2460 -2500 {lab=IN28}
N 980 -2360 2470 -2360 {lab=IN29}
N 980 -2220 2470 -2220 {lab=IN30}
N 2500 -2190 2560 -2190 {lab=B0B}
N 1700 -6850 1760 -6850 {lab=VDD}
N 1700 -6850 1700 -6790 {lab=VDD}
N 1900 -6850 1960 -6850 {lab=VDD}
N 1900 -6850 1900 -6790 {lab=VDD}
N 2100 -6850 2160 -6850 {lab=VDD}
N 2100 -6850 2100 -6790 {lab=VDD}
N 2300 -6850 2360 -6850 {lab=VDD}
N 2300 -6850 2300 -6790 {lab=VDD}
N 2500 -6850 2560 -6850 {lab=VDD}
N 2500 -6850 2500 -6790 {lab=VDD}
N 1760 -6450 1760 -2190 {lab=B4B}
N 1960 -6450 1960 -2190 {lab=B3B}
N 2160 -6450 2160 -2190 {lab=B2B}
N 2360 -6450 2360 -2190 {lab=B1B}
N 2560 -6450 2560 -2190 {lab=B0B}
N 3540 -6450 3540 -6380 {lab=B4B}
N 3740 -6510 3740 -6380 {lab=B3B}
N 3940 -6570 3940 -6380 {lab=B2B}
N 4140 -6630 4140 -6350 {lab=B1B}
N 4340 -6690 4340 -6360 {lab=B0B}
N 3540 -6470 3540 -6450 {lab=B4B}
N 1760 -6470 3540 -6470 {lab=B4B}
N 1760 -6470 1760 -6450 {lab=B4B}
N 1760 -6790 1760 -6470 {lab=B4B}
N 1960 -6790 1960 -6450 {lab=B3B}
N 2160 -6790 2160 -6450 {lab=B2B}
N 2360 -6790 2360 -6450 {lab=B1B}
N 2560 -6790 2560 -6450 {lab=B0B}
N 1960 -6510 3740 -6510 {lab=B3B}
N 2160 -6570 3940 -6570 {lab=B2B}
N 2360 -6630 4140 -6630 {lab=B1B}
N 2560 -6690 4340 -6690 {lab=B0B}
N 3540 -2120 3540 -2030 {lab=B4B}
N 3740 -2130 3740 -2030 {lab=B3B}
N 3940 -2120 3940 -2020 {lab=B2B}
N 4140 -2090 4140 -2010 {lab=B1B}
N 4340 -2100 4340 -2010 {lab=B0B}
N 1690 -1870 1690 -1800 {lab=A}
N 1750 -1870 1750 -1800 {lab=B5}
N 1720 -1930 1720 -1910 {lab=C}
N 1640 -1840 1690 -1840 {lab=A}
N 1750 -1840 1810 -1840 {lab=B5}
N 1690 -1690 1690 -1620 {lab=B}
N 1750 -1690 1750 -1620 {lab=B5}
N 1720 -1580 1720 -1560 {lab=C}
N 1640 -1660 1690 -1660 {lab=B}
N 1750 -1660 1810 -1660 {lab=B5}
N 1720 -1760 1720 -1730 {lab=CBAR}
N 1650 -1740 1720 -1740 {lab=CBAR}
N 1810 -1840 1810 -1660 {lab=B5}
N 1810 -1740 1870 -1740 {lab=B5}
N 2560 -2190 2560 -2110 {lab=B0B}
N 2360 -2190 2360 -2100 {lab=B1B}
N 1960 -2190 1960 -2110 {lab=B3B}
N 1760 -2190 1760 -2110 {lab=B4B}
N 2160 -2190 2160 -2100 {lab=B2B}
N 1110 -1730 1200 -1730 {lab=B5}
N 1170 -1850 1170 -1730 {lab=B5}
N 2590 -1810 2590 -1730 {lab=B3bar}
N 2590 -1810 2660 -1810 {lab=B3bar}
N 2590 -1730 2590 -1660 {lab=B3bar}
N 2590 -1660 2660 -1660 {lab=B3bar}
N 2700 -1780 2700 -1690 {lab=B3}
N 2700 -1730 2810 -1730 {lab=B3}
N 2700 -1630 2700 -1610 {lab=GND}
N 2700 -1860 2700 -1840 {lab=VDD}
N 2550 -1730 2590 -1730 {lab=B3bar}
N 2695 -1810 2710 -1810 {lab=VDD}
N 2700 -1660 2720 -1660 {lab=GND}
N 2370 -1860 2370 -1790 {lab=A}
N 2430 -1860 2430 -1790 {lab=B5}
N 2400 -1920 2400 -1900 {lab=C}
N 2320 -1830 2370 -1830 {lab=A}
N 2430 -1830 2490 -1830 {lab=B5}
N 2370 -1680 2370 -1610 {lab=B}
N 2430 -1680 2430 -1610 {lab=B5}
N 2400 -1570 2400 -1550 {lab=C}
N 2320 -1650 2370 -1650 {lab=B}
N 2430 -1650 2490 -1650 {lab=B5}
N 2400 -1750 2400 -1720 {lab=CBAR}
N 2330 -1730 2400 -1730 {lab=CBAR}
N 2490 -1830 2490 -1650 {lab=B5}
N 2490 -1730 2550 -1730 {lab=B5}
N 1900 -1340 1900 -1260 {lab=B3bar}
N 1900 -1340 1970 -1340 {lab=B3bar}
N 1900 -1260 1900 -1190 {lab=B3bar}
N 1900 -1190 1970 -1190 {lab=B3bar}
N 2010 -1310 2010 -1220 {lab=B3}
N 2010 -1260 2120 -1260 {lab=B3}
N 2010 -1160 2010 -1140 {lab=GND}
N 2010 -1390 2010 -1370 {lab=VDD}
N 1860 -1260 1900 -1260 {lab=B3bar}
N 2005 -1340 2020 -1340 {lab=VDD}
N 2010 -1190 2030 -1190 {lab=GND}
N 1680 -1390 1680 -1320 {lab=A}
N 1740 -1390 1740 -1320 {lab=B5}
N 1710 -1450 1710 -1430 {lab=C}
N 1630 -1360 1680 -1360 {lab=A}
N 1740 -1360 1800 -1360 {lab=B5}
N 1680 -1210 1680 -1140 {lab=B}
N 1740 -1210 1740 -1140 {lab=B5}
N 1710 -1100 1710 -1080 {lab=C}
N 1630 -1180 1680 -1180 {lab=B}
N 1740 -1180 1800 -1180 {lab=B5}
N 1710 -1280 1710 -1250 {lab=CBAR}
N 1640 -1260 1710 -1260 {lab=CBAR}
N 1800 -1360 1800 -1180 {lab=B5}
N 1800 -1260 1860 -1260 {lab=B5}
N 2580 -1330 2580 -1250 {lab=B3bar}
N 2580 -1330 2650 -1330 {lab=B3bar}
N 2580 -1250 2580 -1180 {lab=B3bar}
N 2580 -1180 2650 -1180 {lab=B3bar}
N 2690 -1300 2690 -1210 {lab=B3}
N 2690 -1250 2800 -1250 {lab=B3}
N 2690 -1150 2690 -1130 {lab=GND}
N 2690 -1380 2690 -1360 {lab=VDD}
N 2540 -1250 2580 -1250 {lab=B3bar}
N 2685 -1330 2700 -1330 {lab=VDD}
N 2690 -1180 2710 -1180 {lab=GND}
N 2360 -1380 2360 -1310 {lab=A}
N 2420 -1380 2420 -1310 {lab=B5}
N 2390 -1440 2390 -1420 {lab=C}
N 2310 -1350 2360 -1350 {lab=A}
N 2420 -1350 2480 -1350 {lab=B5}
N 2360 -1200 2360 -1130 {lab=B}
N 2420 -1200 2420 -1130 {lab=B5}
N 2390 -1090 2390 -1070 {lab=C}
N 2310 -1170 2360 -1170 {lab=B}
N 2420 -1170 2480 -1170 {lab=B5}
N 2390 -1270 2390 -1240 {lab=CBAR}
N 2320 -1250 2390 -1250 {lab=CBAR}
N 2480 -1350 2480 -1170 {lab=B5}
N 2480 -1250 2540 -1250 {lab=B5}
N 3330 -1820 3330 -1740 {lab=B3bar}
N 3330 -1820 3400 -1820 {lab=B3bar}
N 3330 -1740 3330 -1670 {lab=B3bar}
N 3330 -1670 3400 -1670 {lab=B3bar}
N 3440 -1790 3440 -1700 {lab=B3}
N 3440 -1740 3550 -1740 {lab=B3}
N 3440 -1640 3440 -1620 {lab=GND}
N 3440 -1870 3440 -1850 {lab=VDD}
N 3290 -1740 3330 -1740 {lab=B3bar}
N 3435 -1820 3450 -1820 {lab=VDD}
N 3440 -1670 3460 -1670 {lab=GND}
N 3110 -1870 3110 -1800 {lab=A}
N 3170 -1870 3170 -1800 {lab=B5}
N 3140 -1930 3140 -1910 {lab=C}
N 3060 -1840 3110 -1840 {lab=A}
N 3170 -1840 3230 -1840 {lab=B5}
N 3110 -1690 3110 -1620 {lab=B}
N 3170 -1690 3170 -1620 {lab=B5}
N 3140 -1580 3140 -1560 {lab=C}
N 3060 -1660 3110 -1660 {lab=B}
N 3170 -1660 3230 -1660 {lab=B5}
N 3140 -1760 3140 -1730 {lab=CBAR}
N 3070 -1740 3140 -1740 {lab=CBAR}
N 3230 -1840 3230 -1660 {lab=B5}
N 3230 -1740 3290 -1740 {lab=B5}
C {lab_wire.sym} 2500 -6790 0 0 {name=p526 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 2500 -6320 0 0 {name=p528 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -6360 0 0 {name=M218
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -6360 0 0 {name=p529 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -6040 0 0 {name=p530 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -6080 0 0 {name=M219
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -6080 0 0 {name=p531 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -5760 0 0 {name=p532 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -5800 0 0 {name=M220
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -5800 0 0 {name=p533 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -6040 0 0 {name=p534 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -6080 0 0 {name=M221
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -6080 0 0 {name=p535 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2300 -6180 0 0 {name=p536 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -6220 0 0 {name=M222
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -6220 0 0 {name=p537 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2300 -5620 0 0 {name=p538 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -5660 0 0 {name=M223
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -5660 0 0 {name=p539 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -5480 0 0 {name=p540 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -5520 0 0 {name=M224
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -5520 0 0 {name=p541 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -5480 0 0 {name=p542 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -5520 0 0 {name=M225
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -5520 0 0 {name=p543 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -5760 0 0 {name=p544 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -5800 0 0 {name=M226
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -5800 0 0 {name=p545 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -5900 0 0 {name=p546 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -5940 0 0 {name=M227
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -5940 0 0 {name=p547 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -5480 0 0 {name=p548 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -5520 0 0 {name=M228
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -5520 0 0 {name=p549 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -5620 0 0 {name=p550 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -5660 0 0 {name=M229
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -5660 0 0 {name=p551 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -5200 0 0 {name=p552 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -5240 0 0 {name=M230
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -5240 0 0 {name=p553 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -4920 0 0 {name=p554 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -4960 0 0 {name=M231
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -4960 0 0 {name=p555 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2500 -4640 0 0 {name=p556 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -4680 0 0 {name=M232
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -4680 0 0 {name=p557 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2300 -4920 0 0 {name=p558 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -4960 0 0 {name=M233
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -4960 0 0 {name=p559 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -5060 0 0 {name=p560 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -5100 0 0 {name=M234
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -5100 0 0 {name=p561 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -4500 0 0 {name=p562 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -4540 0 0 {name=M235
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -4540 0 0 {name=p563 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -4360 0 0 {name=p564 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -4400 0 0 {name=M236
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -4400 0 0 {name=p565 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -4360 0 0 {name=p566 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -4400 0 0 {name=M237
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -4400 0 0 {name=p567 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -4640 0 0 {name=p568 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -4680 0 0 {name=M238
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -4680 0 0 {name=p569 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -4780 0 0 {name=p570 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -4820 0 0 {name=M239
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -4820 0 0 {name=p571 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -4360 0 0 {name=p572 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -4400 0 0 {name=M240
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -4400 0 0 {name=p573 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -4500 0 0 {name=p574 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -4540 0 0 {name=M241
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -4540 0 0 {name=p575 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -5200 0 0 {name=p576 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -5240 0 0 {name=M242
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -5240 0 0 {name=p577 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -5340 0 0 {name=p578 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -5380 0 0 {name=M243
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -5380 0 0 {name=p579 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4920 0 0 {name=p580 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4960 0 0 {name=M244
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4960 0 0 {name=p581 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -5060 0 0 {name=p582 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -5100 0 0 {name=M245
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -5100 0 0 {name=p583 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4640 0 0 {name=p584 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4680 0 0 {name=M246
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4680 0 0 {name=p585 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4780 0 0 {name=p586 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4820 0 0 {name=M247
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4820 0 0 {name=p587 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4360 0 0 {name=p588 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4400 0 0 {name=M248
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4400 0 0 {name=p589 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4500 0 0 {name=p590 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4540 0 0 {name=M249
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4540 0 0 {name=p591 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -4220 0 0 {name=p592 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -4260 0 0 {name=M250
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -4260 0 0 {name=p593 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -4080 0 0 {name=p594 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -4120 0 0 {name=M251
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -4120 0 0 {name=p595 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -3800 0 0 {name=p596 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -3840 0 0 {name=M252
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -3840 0 0 {name=p597 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -3520 0 0 {name=p598 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -3560 0 0 {name=M253
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -3560 0 0 {name=p599 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -3800 0 0 {name=p600 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -3840 0 0 {name=M254
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -3840 0 0 {name=p601 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -3940 0 0 {name=p602 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -3980 0 0 {name=M255
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -3980 0 0 {name=p603 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -3380 0 0 {name=p604 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -3420 0 0 {name=M256
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -3420 0 0 {name=p605 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -3240 0 0 {name=p606 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -3280 0 0 {name=M257
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -3280 0 0 {name=p607 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -3240 0 0 {name=p608 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -3280 0 0 {name=M258
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -3280 0 0 {name=p609 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -3520 0 0 {name=p610 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -3560 0 0 {name=M259
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -3560 0 0 {name=p611 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -3660 0 0 {name=p612 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -3700 0 0 {name=M260
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -3700 0 0 {name=p613 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -3240 0 0 {name=p614 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -3280 0 0 {name=M261
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -3280 0 0 {name=p615 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -3380 0 0 {name=p616 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -3420 0 0 {name=M262
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -3420 0 0 {name=p617 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -2960 0 0 {name=p618 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -3000 0 0 {name=M263
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -3000 0 0 {name=p619 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -2680 0 0 {name=p620 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -2720 0 0 {name=M264
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -2720 0 0 {name=p621 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -2400 0 0 {name=p622 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -2440 0 0 {name=M265
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -2440 0 0 {name=p623 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -2680 0 0 {name=p624 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -2720 0 0 {name=M266
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -2720 0 0 {name=p625 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -2820 0 0 {name=p626 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -2860 0 0 {name=M267
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -2860 0 0 {name=p627 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -2260 0 0 {name=p628 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -2300 0 0 {name=M268
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -2300 0 0 {name=p629 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -2120 0 0 {name=p630 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -2160 0 0 {name=M269
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -2160 0 0 {name=p631 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -2120 0 0 {name=p632 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -2160 0 0 {name=M270
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -2160 0 0 {name=p633 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -2400 0 0 {name=p634 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -2440 0 0 {name=M271
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -2440 0 0 {name=p635 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -2540 0 0 {name=p636 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -2580 0 0 {name=M272
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -2580 0 0 {name=p637 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -2120 0 0 {name=p638 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -2160 0 0 {name=M273
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -2160 0 0 {name=p639 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -2260 0 0 {name=p640 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -2300 0 0 {name=M274
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -2300 0 0 {name=p641 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2960 0 0 {name=p642 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -3000 0 0 {name=M275
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -3000 0 0 {name=p643 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -3100 0 0 {name=p644 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -3140 0 0 {name=M276
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -3140 0 0 {name=p645 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2680 0 0 {name=p646 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2720 0 0 {name=M277
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2720 0 0 {name=p647 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2820 0 0 {name=p648 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2860 0 0 {name=M278
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2860 0 0 {name=p649 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2400 0 0 {name=p650 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2440 0 0 {name=M279
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2440 0 0 {name=p651 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2540 0 0 {name=p652 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2580 0 0 {name=M280
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2580 0 0 {name=p653 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2120 0 0 {name=p654 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2160 0 0 {name=M281
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2160 0 0 {name=p655 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2260 0 0 {name=p656 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2300 0 0 {name=M282
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2300 0 0 {name=p657 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -6260 0 0 {name=p658 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -6300 0 0 {name=M283
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -6300 0 0 {name=p659 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -5980 0 0 {name=p660 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -6020 0 0 {name=M284
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -6020 0 0 {name=p661 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -5700 0 0 {name=p662 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -5740 0 0 {name=M285
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -5740 0 0 {name=p663 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -5980 0 0 {name=p664 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -6020 0 0 {name=M286
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -6020 0 0 {name=p665 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -6120 0 0 {name=p666 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -6160 0 0 {name=M287
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -6160 0 0 {name=p667 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -5560 0 0 {name=p668 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -5600 0 0 {name=M288
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -5600 0 0 {name=p669 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -5420 0 0 {name=p670 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -5460 0 0 {name=M289
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -5460 0 0 {name=p671 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -5420 0 0 {name=p672 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -5460 0 0 {name=M290
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -5460 0 0 {name=p673 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -5700 0 0 {name=p674 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -5740 0 0 {name=M291
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -5740 0 0 {name=p675 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -5840 0 0 {name=p676 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -5880 0 0 {name=M292
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -5880 0 0 {name=p677 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -5420 0 0 {name=p678 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -5460 0 0 {name=M293
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -5460 0 0 {name=p679 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -5560 0 0 {name=p680 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -5600 0 0 {name=M294
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -5600 0 0 {name=p681 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -5140 0 0 {name=p682 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -5180 0 0 {name=M295
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -5180 0 0 {name=p683 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -4860 0 0 {name=p684 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -4900 0 0 {name=M296
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -4900 0 0 {name=p685 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -4580 0 0 {name=p686 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -4620 0 0 {name=M297
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -4620 0 0 {name=p687 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4080 -4860 0 0 {name=p688 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -4900 0 0 {name=M298
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -4900 0 0 {name=p689 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -5000 0 0 {name=p690 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -5040 0 0 {name=M299
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -5040 0 0 {name=p691 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -4440 0 0 {name=p692 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -4480 0 0 {name=M300
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -4480 0 0 {name=p693 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -4300 0 0 {name=p694 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -4340 0 0 {name=M301
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -4340 0 0 {name=p695 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -4300 0 0 {name=p696 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -4340 0 0 {name=M302
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -4340 0 0 {name=p697 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -4580 0 0 {name=p698 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -4620 0 0 {name=M303
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -4620 0 0 {name=p699 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -4720 0 0 {name=p700 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -4760 0 0 {name=M304
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -4760 0 0 {name=p701 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -4300 0 0 {name=p702 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -4340 0 0 {name=M305
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -4340 0 0 {name=p703 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -4440 0 0 {name=p704 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -4480 0 0 {name=M306
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -4480 0 0 {name=p705 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -5140 0 0 {name=p706 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -5180 0 0 {name=M307
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -5180 0 0 {name=p707 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -5280 0 0 {name=p708 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -5320 0 0 {name=M308
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -5320 0 0 {name=p709 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -4860 0 0 {name=p710 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -4900 0 0 {name=M309
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -4900 0 0 {name=p711 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -5000 0 0 {name=p712 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -5040 0 0 {name=M310
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -5040 0 0 {name=p713 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -4580 0 0 {name=p714 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -4620 0 0 {name=M311
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -4620 0 0 {name=p715 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -4720 0 0 {name=p716 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -4760 0 0 {name=M312
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -4760 0 0 {name=p717 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -4300 0 0 {name=p718 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -4340 0 0 {name=M313
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -4340 0 0 {name=p719 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -4440 0 0 {name=p720 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -4480 0 0 {name=M314
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -4480 0 0 {name=p721 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -4020 0 0 {name=p722 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -4060 0 0 {name=M315
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -4060 0 0 {name=p723 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -3740 0 0 {name=p724 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -3780 0 0 {name=M316
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -3780 0 0 {name=p725 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -3460 0 0 {name=p726 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -3500 0 0 {name=M317
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -3500 0 0 {name=p727 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -3740 0 0 {name=p728 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -3780 0 0 {name=M318
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -3780 0 0 {name=p729 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -3880 0 0 {name=p730 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -3920 0 0 {name=M319
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -3920 0 0 {name=p731 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -3320 0 0 {name=p732 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -3360 0 0 {name=M320
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -3360 0 0 {name=p733 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -3180 0 0 {name=p734 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -3220 0 0 {name=M321
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -3220 0 0 {name=p735 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -3180 0 0 {name=p736 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -3220 0 0 {name=M322
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -3220 0 0 {name=p737 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -3460 0 0 {name=p738 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -3500 0 0 {name=M323
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -3500 0 0 {name=p739 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -3600 0 0 {name=p740 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -3640 0 0 {name=M324
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -3640 0 0 {name=p741 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -3180 0 0 {name=p742 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -3220 0 0 {name=M325
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -3220 0 0 {name=p743 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -3320 0 0 {name=p744 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -3360 0 0 {name=M326
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -3360 0 0 {name=p745 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -2900 0 0 {name=p746 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -2940 0 0 {name=M327
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -2940 0 0 {name=p747 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -2620 0 0 {name=p748 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -2660 0 0 {name=M328
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -2660 0 0 {name=p749 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -2340 0 0 {name=p750 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -2380 0 0 {name=M329
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -2380 0 0 {name=p751 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -2620 0 0 {name=p752 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -2660 0 0 {name=M330
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -2660 0 0 {name=p753 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -2760 0 0 {name=p754 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -2800 0 0 {name=M331
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -2800 0 0 {name=p755 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4080 -2200 0 0 {name=p756 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -2240 0 0 {name=M332
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -2240 0 0 {name=p757 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4280 -2060 0 0 {name=p758 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4260 -2100 0 0 {name=M333
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4295 -2100 0 0 {name=p759 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4080 -2060 0 0 {name=p760 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4060 -2100 0 0 {name=M334
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4095 -2100 0 0 {name=p761 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -2340 0 0 {name=p762 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -2380 0 0 {name=M335
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -2380 0 0 {name=p763 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -2480 0 0 {name=p764 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -2520 0 0 {name=M336
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -2520 0 0 {name=p765 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -2060 0 0 {name=p766 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -2100 0 0 {name=M337
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -2100 0 0 {name=p767 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3880 -2200 0 0 {name=p768 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3860 -2240 0 0 {name=M338
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3895 -2240 0 0 {name=p769 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -2900 0 0 {name=p770 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -2940 0 0 {name=M339
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -2940 0 0 {name=p771 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -3040 0 0 {name=p772 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -3080 0 0 {name=M340
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -3080 0 0 {name=p773 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -2620 0 0 {name=p774 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -2660 0 0 {name=M341
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -2660 0 0 {name=p775 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -2760 0 0 {name=p776 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -2800 0 0 {name=M342
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -2800 0 0 {name=p777 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -2340 0 0 {name=p778 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -2380 0 0 {name=M343
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -2380 0 0 {name=p779 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -2480 0 0 {name=p780 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -2520 0 0 {name=M344
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -2520 0 0 {name=p781 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -2060 0 0 {name=p782 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -2100 0 0 {name=M345
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -2100 0 0 {name=p783 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3680 -2200 0 0 {name=p784 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3660 -2240 0 0 {name=M346
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3695 -2240 0 0 {name=p785 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3940 0 0 {name=p786 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3980 0 0 {name=M347
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3980 0 0 {name=p787 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -4080 0 0 {name=p788 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -4120 0 0 {name=M348
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -4120 0 0 {name=p789 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3660 0 0 {name=p790 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3700 0 0 {name=M349
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3700 0 0 {name=p791 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3800 0 0 {name=p792 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3840 0 0 {name=M350
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3840 0 0 {name=p793 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3380 0 0 {name=p794 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3420 0 0 {name=M351
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3420 0 0 {name=p795 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3520 0 0 {name=p796 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3560 0 0 {name=M352
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3560 0 0 {name=p797 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3240 0 0 {name=p798 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3280 0 0 {name=M353
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3280 0 0 {name=p799 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3100 0 0 {name=p800 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3140 0 0 {name=M354
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3140 0 0 {name=p801 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2820 0 0 {name=p802 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2860 0 0 {name=M355
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2860 0 0 {name=p803 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2960 0 0 {name=p804 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3000 0 0 {name=M356
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3000 0 0 {name=p805 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2540 0 0 {name=p806 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2580 0 0 {name=M357
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2580 0 0 {name=p807 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2680 0 0 {name=p808 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2720 0 0 {name=M358
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2720 0 0 {name=p809 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2260 0 0 {name=p810 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2300 0 0 {name=M359
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2300 0 0 {name=p811 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2400 0 0 {name=p812 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2440 0 0 {name=M360
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2440 0 0 {name=p813 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2120 0 0 {name=p814 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2160 0 0 {name=M361
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2160 0 0 {name=p815 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -4160 0 0 {name=p816 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -4200 0 0 {name=M362
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -4200 0 0 {name=p817 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -3880 0 0 {name=p818 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -3920 0 0 {name=M363
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -3920 0 0 {name=p819 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -4020 0 0 {name=p820 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -4060 0 0 {name=M364
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -4060 0 0 {name=p821 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -3600 0 0 {name=p822 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -3640 0 0 {name=M365
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -3640 0 0 {name=p823 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -3740 0 0 {name=p824 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -3780 0 0 {name=M366
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -3780 0 0 {name=p825 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -3320 0 0 {name=p826 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -3360 0 0 {name=M367
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -3360 0 0 {name=p827 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -3460 0 0 {name=p828 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -3500 0 0 {name=M368
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -3500 0 0 {name=p829 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -3180 0 0 {name=p830 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -3220 0 0 {name=M369
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -3220 0 0 {name=p831 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -3040 0 0 {name=p832 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -3080 0 0 {name=M370
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -3080 0 0 {name=p833 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -2760 0 0 {name=p834 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -2800 0 0 {name=M371
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -2800 0 0 {name=p835 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -2900 0 0 {name=p836 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -2940 0 0 {name=M372
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -2940 0 0 {name=p837 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -2480 0 0 {name=p838 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -2520 0 0 {name=M373
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -2520 0 0 {name=p839 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -2620 0 0 {name=p840 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -2660 0 0 {name=M374
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -2660 0 0 {name=p841 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -2200 0 0 {name=p842 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -2240 0 0 {name=M375
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -2240 0 0 {name=p843 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -2340 0 0 {name=p844 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -2380 0 0 {name=M376
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -2380 0 0 {name=p845 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3480 -2060 0 0 {name=p846 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3460 -2100 0 0 {name=M377
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3495 -2100 0 0 {name=p847 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -6790 0 0 {name=p912 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 2100 -6790 0 0 {name=p914 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 1900 -6790 0 0 {name=p916 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 1700 -6790 0 0 {name=p918 sig_type=std_logic lab=VDD
m=55}
C {ipin.sym} 970 -6360 0 0 {name=p950 lab=IN0}
C {ipin.sym} 980 -6220 0 0 {name=p951 lab=IN1}
C {ipin.sym} 980 -6140 0 0 {name=p952 lab=IN2}
C {ipin.sym} 980 -6000 0 0 {name=p953 lab=IN3}
C {ipin.sym} 970 -5860 0 0 {name=p954 lab=IN4
m=1}
C {ipin.sym} 980 -5720 0 0 {name=p955 lab=IN5
m=1}
C {ipin.sym} 990 -5580 0 0 {name=p956 lab=IN6
m=1}
C {ipin.sym} 990 -5440 0 0 {name=p957 lab=IN7
m=1}
C {ipin.sym} 1000 -5300 0 0 {name=p958 lab=IN8
m=1}
C {ipin.sym} 990 -5160 0 0 {name=p959 lab=IN9
m=1}
C {ipin.sym} 1000 -5020 0 0 {name=p960 lab=IN10
m=1}
C {ipin.sym} 1000 -4880 0 0 {name=p961 lab=IN11
m=1}
C {ipin.sym} 1010 -4740 0 0 {name=p962 lab=IN12
m=1}
C {ipin.sym} 1000 -4600 0 0 {name=p963 lab=IN13
m=1}
C {ipin.sym} 1010 -4460 0 0 {name=p964 lab=IN14
m=1}
C {ipin.sym} 1010 -4320 0 0 {name=p965 lab=IN15
m=1}
C {ipin.sym} 1020 -4180 0 0 {name=p966 lab=IN16
m=1}
C {ipin.sym} 1000 -4040 0 0 {name=p967 lab=IN17
m=1}
C {ipin.sym} 1010 -3900 0 0 {name=p968 lab=IN18
m=1}
C {ipin.sym} 1010 -3760 0 0 {name=p969 lab=IN19
m=1}
C {ipin.sym} 1020 -3620 0 0 {name=p970 lab=IN20
m=1}
C {ipin.sym} 1010 -3480 0 0 {name=p971 lab=IN21
m=1}
C {ipin.sym} 1020 -3340 0 0 {name=p972 lab=IN22
m=1}
C {ipin.sym} 1010 -3200 0 0 {name=p973 lab=IN23
m=1}
C {ipin.sym} 1020 -3060 0 0 {name=p974 lab=IN24
m=1}
C {ipin.sym} 1020 -2920 0 0 {name=p975 lab=IN25
m=1}
C {ipin.sym} 1030 -2780 0 0 {name=p976 lab=IN26
m=1}
C {ipin.sym} 1020 -2640 0 0 {name=p977 lab=IN27
m=1}
C {ipin.sym} 1030 -2500 0 0 {name=p978 lab=IN28
m=1}
C {ipin.sym} 1030 -2360 0 0 {name=p979 lab=IN29
m=1}
C {ipin.sym} 1040 -2220 0 0 {name=p980 lab=IN30
m=1}
C {ipin.sym} 2810 -6360 0 0 {name=p982 lab=IN32
m=1}
C {ipin.sym} 2800 -6220 0 0 {name=p983 lab=IN33
m=1}
C {ipin.sym} 2820 -6080 0 0 {name=p984 lab=IN34
m=1}
C {ipin.sym} 2820 -5940 0 0 {name=p985 lab=IN35
m=1}
C {ipin.sym} 2830 -5800 0 0 {name=p986 lab=IN36
m=1}
C {ipin.sym} 2820 -5660 0 0 {name=p987 lab=IN37
m=1}
C {ipin.sym} 2830 -5520 0 0 {name=p988 lab=IN38
m=1}
C {ipin.sym} 2830 -5380 0 0 {name=p989 lab=IN39
m=1}
C {ipin.sym} 2840 -5240 0 0 {name=p990 lab=IN40
m=1}
C {ipin.sym} 2830 -5100 0 0 {name=p991 lab=IN41
m=1}
C {ipin.sym} 2840 -4960 0 0 {name=p992 lab=IN42}
C {ipin.sym} 2840 -4820 0 0 {name=p993 lab=IN43
m=1}
C {ipin.sym} 2850 -4680 0 0 {name=p994 lab=IN44
m=1}
C {ipin.sym} 2830 -4540 0 0 {name=p995 lab=IN45
m=1}
C {ipin.sym} 2840 -4400 0 0 {name=p996 lab=IN46
m=1}
C {ipin.sym} 2840 -4260 0 0 {name=p997 lab=IN47
m=1}
C {ipin.sym} 2850 -4120 0 0 {name=p998 lab=IN48
m=1}
C {ipin.sym} 2840 -3980 0 0 {name=p999 lab=IN49
m=1}
C {ipin.sym} 2850 -3840 0 0 {name=p1000 lab=IN50
m=1}
C {ipin.sym} 2840 -3700 0 0 {name=p1001 lab=IN51
m=1}
C {ipin.sym} 2850 -3560 0 0 {name=p1002 lab=IN52
m=1}
C {ipin.sym} 2850 -3420 0 0 {name=p1003 lab=IN53
m=1}
C {ipin.sym} 2860 -3280 0 0 {name=p1004 lab=IN54
m=1}
C {ipin.sym} 2850 -3140 0 0 {name=p1005 lab=IN55
m=1}
C {ipin.sym} 2860 -3000 0 0 {name=p1006 lab=IN56
m=1}
C {ipin.sym} 2860 -2860 0 0 {name=p1007 lab=IN57
m=1}
C {ipin.sym} 2870 -2720 0 0 {name=p1008 lab=IN58
m=1}
C {ipin.sym} 2850 -2580 0 0 {name=p1009 lab=IN59
m=1}
C {ipin.sym} 2860 -2440 0 0 {name=p1010 lab=IN60
m=1}
C {ipin.sym} 2860 -2300 0 0 {name=p1011 lab=IN61
m=1}
C {ipin.sym} 2870 -2160 0 0 {name=p1012 lab=IN62
m=1}
C {lab_wire.sym} 1350 -1860 0 0 {name=p1020 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1350 -1620 0 0 {name=p1021 sig_type=std_logic lab=GND}
C {symbols/pfet_03v3.sym} 1330 -1810 0 0 {name=M423
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 1330 -1660 0 0 {name=M424
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 1355 -1810 0 0 {name=p1023 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1365 -1660 0 0 {name=p1024 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2020 -1870 0 0 {name=p1025 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2020 -1630 0 0 {name=p1026 sig_type=std_logic lab=GND}
C {symbols/pfet_03v3.sym} 2000 -1820 0 0 {name=M425
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 2000 -1670 0 0 {name=M426
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 2025 -1820 0 0 {name=p1028 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2035 -1670 0 0 {name=p1029 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3540 -2030 0 0 {name=p1046 sig_type=std_logic lab=B4B}
C {lab_wire.sym} 3740 -2030 0 0 {name=p1047 sig_type=std_logic lab=B3B}
C {lab_wire.sym} 3940 -2020 0 0 {name=p1048 sig_type=std_logic lab=B2B}
C {lab_wire.sym} 4140 -2030 0 0 {name=p1049 sig_type=std_logic lab=B1B}
C {lab_wire.sym} 4340 -2010 0 0 {name=p1050 sig_type=std_logic lab=B0B}
C {opin.sym} 1170 -1850 0 0 {name=p945 lab=B5}
C {opin.sym} 2130 -1740 0 0 {name=p946 lab=B0}
C {symbols/ppolyf_u_1k.sym} 1760 -6820 0 0 {name=R1
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 1740 -6820 3 0 {name=p4 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 1960 -6820 0 0 {name=R2
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 1940 -6820 3 0 {name=p5 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 2160 -6820 0 0 {name=R3
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 2140 -6820 3 0 {name=p6 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 2360 -6820 0 0 {name=R4
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 2340 -6820 3 0 {name=p7 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 2560 -6820 0 0 {name=R5
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 2540 -6820 3 0 {name=p8 sig_type=std_logic lab=GND}
C {ipin.sym} 1110 -1730 0 0 {name=p1 lab=THEROMETER_32}
C {lab_wire.sym} 2500 -6790 0 0 {name=p2 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 2500 -6320 0 0 {name=p3 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -6360 0 0 {name=M1
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -6360 0 0 {name=p9 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -6040 0 0 {name=p10 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -6080 0 0 {name=M2
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -6080 0 0 {name=p11 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -5760 0 0 {name=p12 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -5800 0 0 {name=M3
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -5800 0 0 {name=p13 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -6040 0 0 {name=p14 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -6080 0 0 {name=M4
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -6080 0 0 {name=p15 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2300 -6180 0 0 {name=p16 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -6220 0 0 {name=M5
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -6220 0 0 {name=p17 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2300 -5620 0 0 {name=p18 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -5660 0 0 {name=M6
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -5660 0 0 {name=p19 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -5480 0 0 {name=p20 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -5520 0 0 {name=M7
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -5520 0 0 {name=p21 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -5480 0 0 {name=p22 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -5520 0 0 {name=M8
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -5520 0 0 {name=p23 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -5760 0 0 {name=p24 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -5800 0 0 {name=M9
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -5800 0 0 {name=p25 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -5900 0 0 {name=p26 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -5940 0 0 {name=M10
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -5940 0 0 {name=p27 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -5480 0 0 {name=p28 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -5520 0 0 {name=M11
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -5520 0 0 {name=p29 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -5620 0 0 {name=p30 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -5660 0 0 {name=M12
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -5660 0 0 {name=p31 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -5200 0 0 {name=p32 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -5240 0 0 {name=M13
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -5240 0 0 {name=p33 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -4920 0 0 {name=p34 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -4960 0 0 {name=M14
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -4960 0 0 {name=p35 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2500 -4640 0 0 {name=p36 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -4680 0 0 {name=M15
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -4680 0 0 {name=p37 sig_type=std_logic lab=GND}
C {lab_wire.sym} 2300 -4920 0 0 {name=p38 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -4960 0 0 {name=M16
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -4960 0 0 {name=p39 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -5060 0 0 {name=p40 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -5100 0 0 {name=M17
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -5100 0 0 {name=p41 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -4500 0 0 {name=p42 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -4540 0 0 {name=M18
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -4540 0 0 {name=p43 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -4360 0 0 {name=p44 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -4400 0 0 {name=M19
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -4400 0 0 {name=p45 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -4360 0 0 {name=p46 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -4400 0 0 {name=M20
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -4400 0 0 {name=p47 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -4640 0 0 {name=p48 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -4680 0 0 {name=M21
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -4680 0 0 {name=p49 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -4780 0 0 {name=p50 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -4820 0 0 {name=M22
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -4820 0 0 {name=p51 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -4360 0 0 {name=p52 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -4400 0 0 {name=M23
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -4400 0 0 {name=p53 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -4500 0 0 {name=p54 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -4540 0 0 {name=M24
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -4540 0 0 {name=p55 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -5200 0 0 {name=p56 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -5240 0 0 {name=M25
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -5240 0 0 {name=p57 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -5340 0 0 {name=p58 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -5380 0 0 {name=M26
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -5380 0 0 {name=p59 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4920 0 0 {name=p60 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4960 0 0 {name=M27
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4960 0 0 {name=p61 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -5060 0 0 {name=p62 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -5100 0 0 {name=M28
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -5100 0 0 {name=p63 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4640 0 0 {name=p64 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4680 0 0 {name=M29
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4680 0 0 {name=p65 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4780 0 0 {name=p66 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4820 0 0 {name=M30
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4820 0 0 {name=p67 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4360 0 0 {name=p68 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4400 0 0 {name=M31
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4400 0 0 {name=p69 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -4500 0 0 {name=p70 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -4540 0 0 {name=M32
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -4540 0 0 {name=p71 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -4220 0 0 {name=p72 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -4260 0 0 {name=M33
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -4260 0 0 {name=p73 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -4080 0 0 {name=p74 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -4120 0 0 {name=M34
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -4120 0 0 {name=p75 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -3800 0 0 {name=p76 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -3840 0 0 {name=M35
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -3840 0 0 {name=p77 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -3520 0 0 {name=p78 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -3560 0 0 {name=M36
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -3560 0 0 {name=p79 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -3800 0 0 {name=p80 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -3840 0 0 {name=M37
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -3840 0 0 {name=p81 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -3940 0 0 {name=p82 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -3980 0 0 {name=M38
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -3980 0 0 {name=p83 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -3380 0 0 {name=p84 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -3420 0 0 {name=M39
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -3420 0 0 {name=p85 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -3240 0 0 {name=p86 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -3280 0 0 {name=M40
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -3280 0 0 {name=p87 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -3240 0 0 {name=p88 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -3280 0 0 {name=M41
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -3280 0 0 {name=p89 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -3520 0 0 {name=p90 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -3560 0 0 {name=M42
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -3560 0 0 {name=p91 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -3660 0 0 {name=p92 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -3700 0 0 {name=M43
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -3700 0 0 {name=p93 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -3240 0 0 {name=p94 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -3280 0 0 {name=M44
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -3280 0 0 {name=p95 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -3380 0 0 {name=p96 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -3420 0 0 {name=M45
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -3420 0 0 {name=p97 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -2960 0 0 {name=p98 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -3000 0 0 {name=M46
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -3000 0 0 {name=p99 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -2680 0 0 {name=p100 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -2720 0 0 {name=M47
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -2720 0 0 {name=p101 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -2400 0 0 {name=p102 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -2440 0 0 {name=M48
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -2440 0 0 {name=p103 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -2680 0 0 {name=p104 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -2720 0 0 {name=M49
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -2720 0 0 {name=p105 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -2820 0 0 {name=p106 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -2860 0 0 {name=M50
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -2860 0 0 {name=p107 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -2260 0 0 {name=p108 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -2300 0 0 {name=M51
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -2300 0 0 {name=p109 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2500 -2120 0 0 {name=p110 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 2480 -2160 0 0 {name=M52
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2515 -2160 0 0 {name=p111 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -2120 0 0 {name=p112 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 2280 -2160 0 0 {name=M53
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2315 -2160 0 0 {name=p113 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -2400 0 0 {name=p114 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -2440 0 0 {name=M54
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -2440 0 0 {name=p115 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -2540 0 0 {name=p116 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -2580 0 0 {name=M55
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -2580 0 0 {name=p117 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -2120 0 0 {name=p118 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -2160 0 0 {name=M56
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -2160 0 0 {name=p119 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2100 -2260 0 0 {name=p120 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 2080 -2300 0 0 {name=M57
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 2115 -2300 0 0 {name=p121 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2960 0 0 {name=p122 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -3000 0 0 {name=M58
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -3000 0 0 {name=p123 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -3100 0 0 {name=p124 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -3140 0 0 {name=M59
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -3140 0 0 {name=p125 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2680 0 0 {name=p126 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2720 0 0 {name=M60
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2720 0 0 {name=p127 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2820 0 0 {name=p128 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2860 0 0 {name=M61
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2860 0 0 {name=p129 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2400 0 0 {name=p130 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2440 0 0 {name=M62
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2440 0 0 {name=p131 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2540 0 0 {name=p132 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2580 0 0 {name=M63
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2580 0 0 {name=p133 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2120 0 0 {name=p134 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2160 0 0 {name=M64
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2160 0 0 {name=p135 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1900 -2260 0 0 {name=p136 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 1880 -2300 0 0 {name=M65
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1915 -2300 0 0 {name=p137 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3940 0 0 {name=p138 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3980 0 0 {name=M66
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3980 0 0 {name=p139 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -4080 0 0 {name=p140 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -4120 0 0 {name=M67
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -4120 0 0 {name=p141 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3660 0 0 {name=p142 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3700 0 0 {name=M68
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3700 0 0 {name=p143 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3800 0 0 {name=p144 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3840 0 0 {name=M69
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3840 0 0 {name=p145 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3380 0 0 {name=p146 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3420 0 0 {name=M70
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3420 0 0 {name=p147 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3520 0 0 {name=p148 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3560 0 0 {name=M71
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3560 0 0 {name=p149 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3240 0 0 {name=p150 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3280 0 0 {name=M72
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3280 0 0 {name=p151 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -3100 0 0 {name=p152 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3140 0 0 {name=M73
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3140 0 0 {name=p153 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2820 0 0 {name=p154 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2860 0 0 {name=M74
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2860 0 0 {name=p155 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2960 0 0 {name=p156 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -3000 0 0 {name=M75
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -3000 0 0 {name=p157 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2540 0 0 {name=p158 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2580 0 0 {name=M76
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2580 0 0 {name=p159 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2680 0 0 {name=p160 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2720 0 0 {name=M77
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2720 0 0 {name=p161 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2260 0 0 {name=p162 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2300 0 0 {name=M78
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2300 0 0 {name=p163 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2400 0 0 {name=p164 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2440 0 0 {name=M79
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2440 0 0 {name=p165 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 1700 -2120 0 0 {name=p166 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 1680 -2160 0 0 {name=M80
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 1715 -2160 0 0 {name=p167 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 2300 -6790 0 0 {name=p168 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 2100 -6790 0 0 {name=p169 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 1900 -6790 0 0 {name=p170 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 1700 -6790 0 0 {name=p171 sig_type=std_logic lab=VDD
m=55}
C {ipin.sym} 970 -6360 0 0 {name=p172 lab=IN0}
C {ipin.sym} 980 -6220 0 0 {name=p173 lab=IN1}
C {ipin.sym} 980 -6140 0 0 {name=p174 lab=IN2}
C {ipin.sym} 980 -6000 0 0 {name=p175 lab=IN3}
C {ipin.sym} 970 -5860 0 0 {name=p176 lab=IN4
m=1}
C {ipin.sym} 980 -5720 0 0 {name=p177 lab=IN5
m=1}
C {ipin.sym} 990 -5580 0 0 {name=p178 lab=IN6
m=1}
C {ipin.sym} 990 -5440 0 0 {name=p179 lab=IN7
m=1}
C {ipin.sym} 1000 -5300 0 0 {name=p180 lab=IN8
m=1}
C {ipin.sym} 990 -5160 0 0 {name=p181 lab=IN9
m=1}
C {ipin.sym} 1000 -5020 0 0 {name=p182 lab=IN10
m=1}
C {ipin.sym} 1000 -4880 0 0 {name=p183 lab=IN11
m=1}
C {ipin.sym} 1010 -4740 0 0 {name=p184 lab=IN12
m=1}
C {ipin.sym} 1000 -4600 0 0 {name=p185 lab=IN13
m=1}
C {ipin.sym} 1010 -4460 0 0 {name=p186 lab=IN14
m=1}
C {ipin.sym} 1010 -4320 0 0 {name=p187 lab=IN15
m=1}
C {ipin.sym} 1020 -4180 0 0 {name=p188 lab=IN16
m=1}
C {ipin.sym} 1000 -4040 0 0 {name=p189 lab=IN17
m=1}
C {ipin.sym} 1010 -3900 0 0 {name=p190 lab=IN18
m=1}
C {ipin.sym} 1010 -3760 0 0 {name=p191 lab=IN19
m=1}
C {ipin.sym} 1020 -3620 0 0 {name=p192 lab=IN20
m=1}
C {ipin.sym} 1010 -3480 0 0 {name=p193 lab=IN21
m=1}
C {ipin.sym} 1020 -3340 0 0 {name=p194 lab=IN22
m=1}
C {ipin.sym} 1010 -3200 0 0 {name=p195 lab=IN23
m=1}
C {ipin.sym} 1020 -3060 0 0 {name=p196 lab=IN24
m=1}
C {ipin.sym} 1020 -2920 0 0 {name=p197 lab=IN25
m=1}
C {ipin.sym} 1030 -2780 0 0 {name=p198 lab=IN26
m=1}
C {ipin.sym} 1020 -2640 0 0 {name=p199 lab=IN27
m=1}
C {ipin.sym} 1030 -2500 0 0 {name=p200 lab=IN28
m=1}
C {ipin.sym} 1030 -2360 0 0 {name=p201 lab=IN29
m=1}
C {ipin.sym} 1040 -2220 0 0 {name=p202 lab=IN30
m=1}
C {symbols/ppolyf_u_1k.sym} 1760 -6820 0 0 {name=R6
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 1740 -6820 3 0 {name=p203 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 1960 -6820 0 0 {name=R7
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 1940 -6820 3 0 {name=p204 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 2160 -6820 0 0 {name=R8
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 2140 -6820 3 0 {name=p205 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 2360 -6820 0 0 {name=R9
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 2340 -6820 3 0 {name=p206 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 2560 -6820 0 0 {name=R10
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 2540 -6820 3 0 {name=p207 sig_type=std_logic lab=GND}
C {symbols/nfet_03v3.sym} 1720 -1890 1 0 {name=M81
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 1720 -1780 3 0 {name=M82
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 1720 -1710 1 0 {name=M83
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 1720 -1600 3 0 {name=M84
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {lab_wire.sym} 1650 -1840 0 0 {name=p211 sig_type=std_logic lab=B0A
m=-3}
C {lab_wire.sym} 1650 -1660 0 0 {name=p212 sig_type=std_logic lab=B0B
m=-3}
C {lab_wire.sym} 2560 -2110 0 0 {name=p237 sig_type=std_logic lab=B0A}
C {lab_wire.sym} 2360 -2110 0 0 {name=p238 sig_type=std_logic lab=B1A}
C {lab_wire.sym} 2160 -2100 0 0 {name=p239 sig_type=std_logic lab=B2A}
C {lab_wire.sym} 1960 -2120 0 0 {name=p240 sig_type=std_logic lab=B3A}
C {lab_wire.sym} 1760 -2120 0 0 {name=p241 sig_type=std_logic lab=B4A}
C {lab_wire.sym} 1440 -1730 0 0 {name=p242 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 1680 -1740 0 0 {name=p210 sig_type=std_logic lab=THEROMETER_32
m=-3}
C {lab_wire.sym} 1720 -1920 0 0 {name=p208 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 1720 -1560 0 0 {name=p209 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 2700 -1860 0 0 {name=p213 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2700 -1620 0 0 {name=p214 sig_type=std_logic lab=GND}
C {symbols/pfet_03v3.sym} 2680 -1810 0 0 {name=M85
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 2680 -1660 0 0 {name=M86
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 2705 -1810 0 0 {name=p215 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2715 -1660 0 0 {name=p216 sig_type=std_logic lab=GND}
C {opin.sym} 2810 -1730 0 0 {name=p217 lab=B1}
C {symbols/nfet_03v3.sym} 2400 -1880 1 0 {name=M87
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 2400 -1770 3 0 {name=M88
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 2400 -1700 1 0 {name=M89
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 2400 -1590 3 0 {name=M90
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {lab_wire.sym} 2330 -1830 0 0 {name=p218 sig_type=std_logic lab=B1A
m=-3}
C {lab_wire.sym} 2330 -1650 0 0 {name=p219 sig_type=std_logic lab=B1B
m=-3}
C {lab_wire.sym} 2360 -1730 0 0 {name=p220 sig_type=std_logic lab=THEROMETER_32
m=-3}
C {lab_wire.sym} 2400 -1910 0 0 {name=p221 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 2400 -1550 0 0 {name=p222 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 2010 -1390 0 0 {name=p223 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2010 -1150 0 0 {name=p224 sig_type=std_logic lab=GND}
C {symbols/pfet_03v3.sym} 1990 -1340 0 0 {name=M91
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 1990 -1190 0 0 {name=M92
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 2015 -1340 0 0 {name=p225 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2025 -1190 0 0 {name=p226 sig_type=std_logic lab=GND}
C {opin.sym} 2120 -1260 0 0 {name=p227 lab=B3}
C {symbols/nfet_03v3.sym} 1710 -1410 1 0 {name=M93
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 1710 -1300 3 0 {name=M94
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 1710 -1230 1 0 {name=M95
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 1710 -1120 3 0 {name=M96
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {lab_wire.sym} 1640 -1360 0 0 {name=p228 sig_type=std_logic lab=B3A
m=-3}
C {lab_wire.sym} 1640 -1180 0 0 {name=p229 sig_type=std_logic lab=B3B
m=-3}
C {lab_wire.sym} 1670 -1260 0 0 {name=p230 sig_type=std_logic lab=THEROMETER_32
m=-3}
C {lab_wire.sym} 1710 -1440 0 0 {name=p231 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 1710 -1080 0 0 {name=p232 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 2690 -1380 0 0 {name=p233 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2690 -1140 0 0 {name=p234 sig_type=std_logic lab=GND}
C {symbols/pfet_03v3.sym} 2670 -1330 0 0 {name=M97
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 2670 -1180 0 0 {name=M98
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 2695 -1330 0 0 {name=p235 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2705 -1180 0 0 {name=p236 sig_type=std_logic lab=GND}
C {opin.sym} 2800 -1250 0 0 {name=p244 lab=B4}
C {symbols/nfet_03v3.sym} 2390 -1400 1 0 {name=M99
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 2390 -1290 3 0 {name=M100
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 2390 -1220 1 0 {name=M101
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 2390 -1110 3 0 {name=M102
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {lab_wire.sym} 2320 -1350 0 0 {name=p245 sig_type=std_logic lab=B4A
m=-3}
C {lab_wire.sym} 2320 -1170 0 0 {name=p246 sig_type=std_logic lab=B4B
m=-3}
C {lab_wire.sym} 2350 -1250 0 0 {name=p247 sig_type=std_logic lab=THEROMETER_32
m=-3}
C {lab_wire.sym} 2390 -1430 0 0 {name=p248 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 2390 -1070 0 0 {name=p249 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 3440 -1870 0 0 {name=p250 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3440 -1630 0 0 {name=p251 sig_type=std_logic lab=GND}
C {symbols/pfet_03v3.sym} 3420 -1820 0 0 {name=M103
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 3420 -1670 0 0 {name=M104
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 3445 -1820 0 0 {name=p252 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3455 -1670 0 0 {name=p253 sig_type=std_logic lab=GND}
C {opin.sym} 3550 -1740 0 0 {name=p254 lab=B2}
C {symbols/nfet_03v3.sym} 3140 -1890 1 0 {name=M105
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 3140 -1780 3 0 {name=M106
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 3140 -1710 1 0 {name=M107
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {symbols/pfet_03v3.sym} 3140 -1600 3 0 {name=M108
L=0.28u
W=0.44u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {lab_wire.sym} 3070 -1840 0 0 {name=p255 sig_type=std_logic lab=B2A
m=-3}
C {lab_wire.sym} 3070 -1660 0 0 {name=p256 sig_type=std_logic lab=B2B
m=-3}
C {lab_wire.sym} 3100 -1740 0 0 {name=p257 sig_type=std_logic lab=THEROMETER_32
m=-3}
C {lab_wire.sym} 3140 -1920 0 0 {name=p258 sig_type=std_logic lab=Thero32_bar
m=-3}
C {lab_wire.sym} 3140 -1560 0 0 {name=p259 sig_type=std_logic lab=Thero32_bar
m=-3}
