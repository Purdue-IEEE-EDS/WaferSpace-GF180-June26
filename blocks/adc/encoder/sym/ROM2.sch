v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 4040 -10340 4040 -10320 {lab=VDD}
N 4040 -10140 4040 -10120 {lab=GND}
N 4040 -10170 4060 -10170 {lab=GND}
N 4040 -9860 4040 -9840 {lab=GND}
N 4040 -9890 4060 -9890 {lab=GND}
N 4040 -9580 4040 -9560 {lab=GND}
N 4040 -9610 4060 -9610 {lab=GND}
N 3840 -9860 3840 -9840 {lab=GND}
N 3840 -9890 3860 -9890 {lab=GND}
N 3840 -10000 3840 -9980 {lab=GND}
N 3840 -10030 3860 -10030 {lab=GND}
N 3840 -9440 3840 -9420 {lab=GND}
N 3840 -9470 3860 -9470 {lab=GND}
N 4040 -9300 4040 -9280 {lab=GND}
N 4040 -9330 4060 -9330 {lab=GND}
N 3840 -9300 3840 -9280 {lab=GND}
N 3840 -9330 3860 -9330 {lab=GND}
N 3640 -9580 3640 -9560 {lab=GND}
N 3640 -9610 3660 -9610 {lab=GND}
N 3640 -9720 3640 -9700 {lab=GND}
N 3640 -9750 3660 -9750 {lab=GND}
N 3640 -9300 3640 -9280 {lab=GND}
N 3640 -9330 3660 -9330 {lab=GND}
N 3640 -9440 3640 -9420 {lab=GND}
N 3640 -9470 3660 -9470 {lab=GND}
N 4040 -9020 4040 -9000 {lab=GND}
N 4040 -9050 4060 -9050 {lab=GND}
N 4040 -8740 4040 -8720 {lab=GND}
N 4040 -8770 4060 -8770 {lab=GND}
N 4040 -8460 4040 -8440 {lab=GND}
N 4040 -8490 4060 -8490 {lab=GND}
N 3840 -8740 3840 -8720 {lab=GND}
N 3840 -8770 3860 -8770 {lab=GND}
N 3840 -8880 3840 -8860 {lab=GND}
N 3840 -8910 3860 -8910 {lab=GND}
N 3840 -8320 3840 -8300 {lab=GND}
N 3840 -8350 3860 -8350 {lab=GND}
N 4040 -8180 4040 -8160 {lab=GND}
N 4040 -8210 4060 -8210 {lab=GND}
N 3840 -8180 3840 -8160 {lab=GND}
N 3840 -8210 3860 -8210 {lab=GND}
N 3640 -8460 3640 -8440 {lab=GND}
N 3640 -8490 3660 -8490 {lab=GND}
N 3640 -8600 3640 -8580 {lab=GND}
N 3640 -8630 3660 -8630 {lab=GND}
N 3640 -8180 3640 -8160 {lab=GND}
N 3640 -8210 3660 -8210 {lab=GND}
N 3640 -8320 3640 -8300 {lab=GND}
N 3640 -8350 3660 -8350 {lab=GND}
N 3440 -9020 3440 -9000 {lab=GND}
N 3440 -9050 3460 -9050 {lab=GND}
N 3440 -9160 3440 -9140 {lab=GND}
N 3440 -9190 3460 -9190 {lab=GND}
N 3440 -8740 3440 -8720 {lab=GND}
N 3440 -8770 3460 -8770 {lab=GND}
N 3440 -8880 3440 -8860 {lab=GND}
N 3440 -8910 3460 -8910 {lab=GND}
N 3440 -8460 3440 -8440 {lab=GND}
N 3440 -8490 3460 -8490 {lab=GND}
N 3440 -8600 3440 -8580 {lab=GND}
N 3440 -8630 3460 -8630 {lab=GND}
N 3440 -8180 3440 -8160 {lab=GND}
N 3440 -8210 3460 -8210 {lab=GND}
N 3440 -8320 3440 -8300 {lab=GND}
N 3440 -8350 3460 -8350 {lab=GND}
N 3240 -8040 3240 -8020 {lab=GND}
N 3240 -8070 3260 -8070 {lab=GND}
N 4040 -7900 4040 -7880 {lab=GND}
N 4040 -7930 4060 -7930 {lab=GND}
N 4040 -7620 4040 -7600 {lab=GND}
N 4040 -7650 4060 -7650 {lab=GND}
N 4040 -7340 4040 -7320 {lab=GND}
N 4040 -7370 4060 -7370 {lab=GND}
N 3840 -7620 3840 -7600 {lab=GND}
N 3840 -7650 3860 -7650 {lab=GND}
N 3840 -7760 3840 -7740 {lab=GND}
N 3840 -7790 3860 -7790 {lab=GND}
N 3840 -7200 3840 -7180 {lab=GND}
N 3840 -7230 3860 -7230 {lab=GND}
N 4040 -7060 4040 -7040 {lab=GND}
N 4040 -7090 4060 -7090 {lab=GND}
N 3840 -7060 3840 -7040 {lab=GND}
N 3840 -7090 3860 -7090 {lab=GND}
N 3640 -7340 3640 -7320 {lab=GND}
N 3640 -7370 3660 -7370 {lab=GND}
N 3640 -7480 3640 -7460 {lab=GND}
N 3640 -7510 3660 -7510 {lab=GND}
N 3640 -7060 3640 -7040 {lab=GND}
N 3640 -7090 3660 -7090 {lab=GND}
N 3640 -7200 3640 -7180 {lab=GND}
N 3640 -7230 3660 -7230 {lab=GND}
N 4040 -6780 4040 -6760 {lab=GND}
N 4040 -6810 4060 -6810 {lab=GND}
N 4040 -6500 4040 -6480 {lab=GND}
N 4040 -6530 4060 -6530 {lab=GND}
N 4040 -6220 4040 -6200 {lab=GND}
N 4040 -6250 4060 -6250 {lab=GND}
N 3840 -6500 3840 -6480 {lab=GND}
N 3840 -6530 3860 -6530 {lab=GND}
N 3840 -6640 3840 -6620 {lab=GND}
N 3840 -6670 3860 -6670 {lab=GND}
N 3840 -6080 3840 -6060 {lab=GND}
N 3840 -6110 3860 -6110 {lab=GND}
N 4040 -5940 4040 -5920 {lab=GND}
N 4040 -5970 4060 -5970 {lab=GND}
N 3840 -5940 3840 -5920 {lab=GND}
N 3840 -5970 3860 -5970 {lab=GND}
N 3640 -6220 3640 -6200 {lab=GND}
N 3640 -6250 3660 -6250 {lab=GND}
N 3640 -6360 3640 -6340 {lab=GND}
N 3640 -6390 3660 -6390 {lab=GND}
N 3640 -5940 3640 -5920 {lab=GND}
N 3640 -5970 3660 -5970 {lab=GND}
N 3640 -6080 3640 -6060 {lab=GND}
N 3640 -6110 3660 -6110 {lab=GND}
N 3440 -6780 3440 -6760 {lab=GND}
N 3440 -6810 3460 -6810 {lab=GND}
N 3440 -6920 3440 -6900 {lab=GND}
N 3440 -6950 3460 -6950 {lab=GND}
N 3440 -6500 3440 -6480 {lab=GND}
N 3440 -6530 3460 -6530 {lab=GND}
N 3440 -6640 3440 -6620 {lab=GND}
N 3440 -6670 3460 -6670 {lab=GND}
N 3440 -6220 3440 -6200 {lab=GND}
N 3440 -6250 3460 -6250 {lab=GND}
N 3440 -6360 3440 -6340 {lab=GND}
N 3440 -6390 3460 -6390 {lab=GND}
N 3440 -5940 3440 -5920 {lab=GND}
N 3440 -5970 3460 -5970 {lab=GND}
N 3440 -6080 3440 -6060 {lab=GND}
N 3440 -6110 3460 -6110 {lab=GND}
N 4460 -10140 4460 -10120 {lab=GND}
N 4440 -10170 4460 -10170 {lab=GND}
N 4460 -9860 4460 -9840 {lab=GND}
N 4440 -9890 4460 -9890 {lab=GND}
N 4460 -9580 4460 -9560 {lab=GND}
N 4440 -9610 4460 -9610 {lab=GND}
N 4660 -9860 4660 -9840 {lab=GND}
N 4640 -9890 4660 -9890 {lab=GND}
N 4660 -10000 4660 -9980 {lab=GND}
N 4640 -10030 4660 -10030 {lab=GND}
N 4660 -9440 4660 -9420 {lab=GND}
N 4640 -9470 4660 -9470 {lab=GND}
N 4460 -9300 4460 -9280 {lab=GND}
N 4440 -9330 4460 -9330 {lab=GND}
N 4660 -9300 4660 -9280 {lab=GND}
N 4640 -9330 4660 -9330 {lab=GND}
N 4860 -9580 4860 -9560 {lab=GND}
N 4840 -9610 4860 -9610 {lab=GND}
N 4860 -9720 4860 -9700 {lab=GND}
N 4840 -9750 4860 -9750 {lab=GND}
N 4860 -9300 4860 -9280 {lab=GND}
N 4840 -9330 4860 -9330 {lab=GND}
N 4860 -9440 4860 -9420 {lab=GND}
N 4840 -9470 4860 -9470 {lab=GND}
N 4460 -9020 4460 -9000 {lab=GND}
N 4440 -9050 4460 -9050 {lab=GND}
N 4460 -8740 4460 -8720 {lab=GND}
N 4440 -8770 4460 -8770 {lab=GND}
N 4460 -8460 4460 -8440 {lab=GND}
N 4440 -8490 4460 -8490 {lab=GND}
N 4660 -8740 4660 -8720 {lab=GND}
N 4640 -8770 4660 -8770 {lab=GND}
N 4660 -8880 4660 -8860 {lab=GND}
N 4640 -8910 4660 -8910 {lab=GND}
N 4660 -8320 4660 -8300 {lab=GND}
N 4640 -8350 4660 -8350 {lab=GND}
N 4460 -8180 4460 -8160 {lab=GND}
N 4440 -8210 4460 -8210 {lab=GND}
N 4660 -8180 4660 -8160 {lab=GND}
N 4640 -8210 4660 -8210 {lab=GND}
N 4860 -8460 4860 -8440 {lab=GND}
N 4840 -8490 4860 -8490 {lab=GND}
N 4860 -8600 4860 -8580 {lab=GND}
N 4840 -8630 4860 -8630 {lab=GND}
N 4860 -8180 4860 -8160 {lab=GND}
N 4840 -8210 4860 -8210 {lab=GND}
N 4860 -8320 4860 -8300 {lab=GND}
N 4840 -8350 4860 -8350 {lab=GND}
N 5060 -9020 5060 -9000 {lab=GND}
N 5040 -9050 5060 -9050 {lab=GND}
N 5060 -9160 5060 -9140 {lab=GND}
N 5040 -9190 5060 -9190 {lab=GND}
N 5060 -8740 5060 -8720 {lab=GND}
N 5040 -8770 5060 -8770 {lab=GND}
N 5060 -8880 5060 -8860 {lab=GND}
N 5040 -8910 5060 -8910 {lab=GND}
N 5060 -8460 5060 -8440 {lab=GND}
N 5040 -8490 5060 -8490 {lab=GND}
N 5060 -8600 5060 -8580 {lab=GND}
N 5040 -8630 5060 -8630 {lab=GND}
N 5060 -8180 5060 -8160 {lab=GND}
N 5040 -8210 5060 -8210 {lab=GND}
N 5060 -8320 5060 -8300 {lab=GND}
N 5040 -8350 5060 -8350 {lab=GND}
N 4460 -7900 4460 -7880 {lab=GND}
N 4440 -7930 4460 -7930 {lab=GND}
N 4460 -7620 4460 -7600 {lab=GND}
N 4440 -7650 4460 -7650 {lab=GND}
N 4460 -7340 4460 -7320 {lab=GND}
N 4440 -7370 4460 -7370 {lab=GND}
N 4660 -7620 4660 -7600 {lab=GND}
N 4640 -7650 4660 -7650 {lab=GND}
N 4660 -7760 4660 -7740 {lab=GND}
N 4640 -7790 4660 -7790 {lab=GND}
N 4660 -7200 4660 -7180 {lab=GND}
N 4640 -7230 4660 -7230 {lab=GND}
N 4460 -7060 4460 -7040 {lab=GND}
N 4440 -7090 4460 -7090 {lab=GND}
N 4660 -7060 4660 -7040 {lab=GND}
N 4640 -7090 4660 -7090 {lab=GND}
N 4860 -7340 4860 -7320 {lab=GND}
N 4840 -7370 4860 -7370 {lab=GND}
N 4860 -7480 4860 -7460 {lab=GND}
N 4840 -7510 4860 -7510 {lab=GND}
N 4860 -7060 4860 -7040 {lab=GND}
N 4840 -7090 4860 -7090 {lab=GND}
N 4860 -7200 4860 -7180 {lab=GND}
N 4840 -7230 4860 -7230 {lab=GND}
N 4460 -6780 4460 -6760 {lab=GND}
N 4440 -6810 4460 -6810 {lab=GND}
N 4460 -6500 4460 -6480 {lab=GND}
N 4440 -6530 4460 -6530 {lab=GND}
N 4460 -6220 4460 -6200 {lab=GND}
N 4440 -6250 4460 -6250 {lab=GND}
N 4660 -6500 4660 -6480 {lab=GND}
N 4640 -6530 4660 -6530 {lab=GND}
N 4660 -6640 4660 -6620 {lab=GND}
N 4640 -6670 4660 -6670 {lab=GND}
N 4660 -6080 4660 -6060 {lab=GND}
N 4640 -6110 4660 -6110 {lab=GND}
N 4460 -5940 4460 -5920 {lab=GND}
N 4440 -5970 4460 -5970 {lab=GND}
N 4660 -5940 4660 -5920 {lab=GND}
N 4640 -5970 4660 -5970 {lab=GND}
N 4860 -6220 4860 -6200 {lab=GND}
N 4840 -6250 4860 -6250 {lab=GND}
N 4860 -6360 4860 -6340 {lab=GND}
N 4840 -6390 4860 -6390 {lab=GND}
N 4860 -5940 4860 -5920 {lab=GND}
N 4840 -5970 4860 -5970 {lab=GND}
N 4860 -6080 4860 -6060 {lab=GND}
N 4840 -6110 4860 -6110 {lab=GND}
N 5060 -6780 5060 -6760 {lab=GND}
N 5040 -6810 5060 -6810 {lab=GND}
N 5060 -6920 5060 -6900 {lab=GND}
N 5040 -6950 5060 -6950 {lab=GND}
N 5060 -6500 5060 -6480 {lab=GND}
N 5040 -6530 5060 -6530 {lab=GND}
N 5060 -6640 5060 -6620 {lab=GND}
N 5040 -6670 5060 -6670 {lab=GND}
N 5060 -6220 5060 -6200 {lab=GND}
N 5040 -6250 5060 -6250 {lab=GND}
N 5060 -6360 5060 -6340 {lab=GND}
N 5040 -6390 5060 -6390 {lab=GND}
N 5060 -5940 5060 -5920 {lab=GND}
N 5040 -5970 5060 -5970 {lab=GND}
N 5060 -6080 5060 -6060 {lab=GND}
N 5040 -6110 5060 -6110 {lab=GND}
N 3240 -7760 3240 -7740 {lab=GND}
N 3240 -7790 3260 -7790 {lab=GND}
N 3240 -7900 3240 -7880 {lab=GND}
N 3240 -7930 3260 -7930 {lab=GND}
N 3240 -7480 3240 -7460 {lab=GND}
N 3240 -7510 3260 -7510 {lab=GND}
N 3240 -7620 3240 -7600 {lab=GND}
N 3240 -7650 3260 -7650 {lab=GND}
N 3240 -7200 3240 -7180 {lab=GND}
N 3240 -7230 3260 -7230 {lab=GND}
N 3240 -7340 3240 -7320 {lab=GND}
N 3240 -7370 3260 -7370 {lab=GND}
N 3240 -7060 3240 -7040 {lab=GND}
N 3240 -7090 3260 -7090 {lab=GND}
N 3240 -6920 3240 -6900 {lab=GND}
N 3240 -6950 3260 -6950 {lab=GND}
N 3240 -6640 3240 -6620 {lab=GND}
N 3240 -6670 3260 -6670 {lab=GND}
N 3240 -6780 3240 -6760 {lab=GND}
N 3240 -6810 3260 -6810 {lab=GND}
N 3240 -6360 3240 -6340 {lab=GND}
N 3240 -6390 3260 -6390 {lab=GND}
N 3240 -6500 3240 -6480 {lab=GND}
N 3240 -6530 3260 -6530 {lab=GND}
N 3240 -6080 3240 -6060 {lab=GND}
N 3240 -6110 3260 -6110 {lab=GND}
N 3240 -6220 3240 -6200 {lab=GND}
N 3240 -6250 3260 -6250 {lab=GND}
N 3240 -5940 3240 -5920 {lab=GND}
N 3240 -5970 3260 -5970 {lab=GND}
N 5260 -8040 5260 -8020 {lab=GND}
N 5240 -8070 5260 -8070 {lab=GND}
N 5260 -7760 5260 -7740 {lab=GND}
N 5240 -7790 5260 -7790 {lab=GND}
N 5260 -7900 5260 -7880 {lab=GND}
N 5240 -7930 5260 -7930 {lab=GND}
N 5260 -7480 5260 -7460 {lab=GND}
N 5240 -7510 5260 -7510 {lab=GND}
N 5260 -7620 5260 -7600 {lab=GND}
N 5240 -7650 5260 -7650 {lab=GND}
N 5260 -7200 5260 -7180 {lab=GND}
N 5240 -7230 5260 -7230 {lab=GND}
N 5260 -7340 5260 -7320 {lab=GND}
N 5240 -7370 5260 -7370 {lab=GND}
N 5260 -7060 5260 -7040 {lab=GND}
N 5240 -7090 5260 -7090 {lab=GND}
N 5260 -6920 5260 -6900 {lab=GND}
N 5240 -6950 5260 -6950 {lab=GND}
N 5260 -6640 5260 -6620 {lab=GND}
N 5240 -6670 5260 -6670 {lab=GND}
N 5260 -6780 5260 -6760 {lab=GND}
N 5240 -6810 5260 -6810 {lab=GND}
N 5260 -6360 5260 -6340 {lab=GND}
N 5240 -6390 5260 -6390 {lab=GND}
N 5260 -6500 5260 -6480 {lab=GND}
N 5240 -6530 5260 -6530 {lab=GND}
N 5260 -6080 5260 -6060 {lab=GND}
N 5240 -6110 5260 -6110 {lab=GND}
N 5260 -6220 5260 -6200 {lab=GND}
N 5240 -6250 5260 -6250 {lab=GND}
N 5260 -5940 5260 -5920 {lab=GND}
N 5240 -5970 5260 -5970 {lab=GND}
N 4040 -10200 4100 -10200 {lab=B0bar}
N 4040 -9920 4100 -9920 {lab=B0bar}
N 4040 -9640 4100 -9640 {lab=B0bar}
N 4040 -9360 4100 -9360 {lab=B0bar}
N 4040 -9080 4100 -9080 {lab=B0bar}
N 4040 -8800 4100 -8800 {lab=B0bar}
N 4040 -8520 4100 -8520 {lab=B0bar}
N 4040 -8240 4100 -8240 {lab=B0bar}
N 4040 -7960 4100 -7960 {lab=B0bar}
N 4040 -7680 4100 -7680 {lab=B0bar}
N 4040 -7400 4100 -7400 {lab=B0bar}
N 4040 -7120 4100 -7120 {lab=B0bar}
N 4040 -6840 4100 -6840 {lab=B0bar}
N 4040 -6560 4100 -6560 {lab=B0bar}
N 4040 -6280 4100 -6280 {lab=B0bar}
N 4400 -10200 4460 -10200 {lab=B0bar_h}
N 4400 -9920 4460 -9920 {lab=B0bar_h}
N 4400 -9640 4460 -9640 {lab=B0bar_h}
N 4400 -9360 4460 -9360 {lab=B0bar_h}
N 4400 -9080 4460 -9080 {lab=B0bar_h}
N 4400 -8800 4460 -8800 {lab=B0bar_h}
N 4400 -8520 4460 -8520 {lab=B0bar_h}
N 4400 -8240 4460 -8240 {lab=B0bar_h}
N 4400 -7960 4460 -7960 {lab=B0bar_h}
N 4400 -7680 4460 -7680 {lab=B0bar_h}
N 4400 -7400 4460 -7400 {lab=B0bar_h}
N 4400 -7120 4460 -7120 {lab=B0bar_h}
N 4400 -6840 4460 -6840 {lab=B0bar_h}
N 4400 -6560 4460 -6560 {lab=B0bar_h}
N 4400 -6280 4460 -6280 {lab=B0bar_h}
N 4400 -6000 4460 -6000 {lab=B0bar_h}
N 3840 -10060 3900 -10060 {lab=B1bar}
N 3840 -9920 3900 -9920 {lab=B1bar}
N 3840 -9500 3900 -9500 {lab=B1bar}
N 3840 -9360 3900 -9360 {lab=B1bar}
N 3840 -8940 3900 -8940 {lab=B1bar}
N 3840 -8800 3900 -8800 {lab=B1bar}
N 3840 -8380 3900 -8380 {lab=B1bar}
N 3840 -8240 3900 -8240 {lab=B1bar}
N 3840 -7820 3900 -7820 {lab=B1bar}
N 3840 -7680 3900 -7680 {lab=B1bar}
N 3840 -7260 3900 -7260 {lab=B1bar}
N 3840 -7120 3900 -7120 {lab=B1bar}
N 3840 -6700 3900 -6700 {lab=B1bar}
N 3840 -6560 3900 -6560 {lab=B1bar}
N 3840 -6140 3900 -6140 {lab=B1bar}
N 3840 -6000 3900 -6000 {lab=B1bar}
N 4600 -10060 4660 -10060 {lab=B1bar_h}
N 4600 -9920 4660 -9920 {lab=B1bar_h}
N 4600 -9500 4660 -9500 {lab=B1bar_h}
N 4600 -9360 4660 -9360 {lab=B1bar_h}
N 4600 -8940 4660 -8940 {lab=B1bar_h}
N 4600 -8800 4660 -8800 {lab=B1bar_h}
N 4600 -8380 4660 -8380 {lab=B1bar_h}
N 4600 -8240 4660 -8240 {lab=B1bar_h}
N 4600 -7820 4660 -7820 {lab=B1bar_h}
N 4600 -7680 4660 -7680 {lab=B1bar_h}
N 4600 -7260 4660 -7260 {lab=B1bar_h}
N 4600 -7120 4660 -7120 {lab=B1bar_h}
N 4600 -6700 4660 -6700 {lab=B1bar_h}
N 4600 -6560 4660 -6560 {lab=B1bar_h}
N 4600 -6140 4660 -6140 {lab=B1bar_h}
N 4600 -6000 4660 -6000 {lab=B1bar_h}
N 3640 -9780 3700 -9780 {lab=B2bar}
N 3640 -9640 3700 -9640 {lab=B2bar}
N 3640 -9500 3700 -9500 {lab=B2bar}
N 3640 -9360 3700 -9360 {lab=B2bar}
N 3640 -8660 3700 -8660 {lab=B2bar}
N 3640 -8520 3700 -8520 {lab=B2bar}
N 3640 -8380 3700 -8380 {lab=B2bar}
N 3640 -8240 3700 -8240 {lab=B2bar}
N 3640 -7540 3700 -7540 {lab=B2bar}
N 3640 -7400 3700 -7400 {lab=B2bar}
N 3640 -7260 3700 -7260 {lab=B2bar}
N 3640 -7120 3700 -7120 {lab=B2bar}
N 3640 -6420 3700 -6420 {lab=B2bar}
N 3640 -6280 3700 -6280 {lab=B2bar}
N 3640 -6140 3700 -6140 {lab=B2bar}
N 3640 -6000 3700 -6000 {lab=B2bar}
N 4800 -9780 4860 -9780 {lab=B2bar_h}
N 4800 -9640 4860 -9640 {lab=B2bar_h}
N 4800 -9500 4860 -9500 {lab=B2bar_h}
N 4800 -9360 4860 -9360 {lab=B2bar_h}
N 4800 -8660 4860 -8660 {lab=B2bar_h}
N 4800 -8520 4860 -8520 {lab=B2bar_h}
N 4800 -8380 4860 -8380 {lab=B2bar_h}
N 4800 -8240 4860 -8240 {lab=B2bar_h}
N 4800 -7540 4860 -7540 {lab=B2bar_h}
N 4800 -7400 4860 -7400 {lab=B2bar_h}
N 4800 -7260 4860 -7260 {lab=B2bar_h}
N 4800 -7120 4860 -7120 {lab=B2bar_h}
N 4800 -6420 4860 -6420 {lab=B2bar_h}
N 4800 -6280 4860 -6280 {lab=B2bar_h}
N 4800 -6140 4860 -6140 {lab=B2bar_h}
N 4800 -6000 4860 -6000 {lab=B2bar_h}
N 3440 -9220 3500 -9220 {lab=B3bar}
N 3440 -9080 3500 -9080 {lab=B3bar}
N 3440 -8940 3500 -8940 {lab=B3bar}
N 3440 -8800 3500 -8800 {lab=B3bar}
N 3440 -8660 3500 -8660 {lab=B3bar}
N 3440 -8520 3500 -8520 {lab=B3bar}
N 3440 -8380 3500 -8380 {lab=B3bar}
N 3440 -8240 3500 -8240 {lab=B3bar}
N 3440 -6980 3500 -6980 {lab=B3bar}
N 3440 -6840 3500 -6840 {lab=B3bar}
N 3440 -6700 3500 -6700 {lab=B3bar}
N 3440 -6560 3500 -6560 {lab=B3bar}
N 3440 -6420 3500 -6420 {lab=B3bar}
N 3440 -6280 3500 -6280 {lab=B3bar}
N 3440 -6140 3500 -6140 {lab=B3bar}
N 3440 -6000 3500 -6000 {lab=B3bar}
N 5000 -9220 5060 -9220 {lab=B3bar_h}
N 5000 -9080 5060 -9080 {lab=B3bar_h}
N 5000 -8940 5060 -8940 {lab=B3bar_h}
N 5000 -8800 5060 -8800 {lab=B3bar_h}
N 5000 -8660 5060 -8660 {lab=B3bar_h}
N 5000 -8520 5060 -8520 {lab=B3bar_h}
N 5000 -8380 5060 -8380 {lab=B3bar_h}
N 5000 -8240 5060 -8240 {lab=B3bar_h}
N 5000 -6980 5060 -6980 {lab=B3bar_h}
N 5000 -6840 5060 -6840 {lab=B3bar_h}
N 5000 -6700 5060 -6700 {lab=B3bar_h}
N 5000 -6560 5060 -6560 {lab=B3bar_h}
N 5000 -6420 5060 -6420 {lab=B3bar_h}
N 5000 -6280 5060 -6280 {lab=B3bar_h}
N 5000 -6140 5060 -6140 {lab=B3bar_h}
N 5000 -6000 5060 -6000 {lab=B3bar_h}
N 3240 -6980 3300 -6980 {lab=B4bar}
N 3240 -6840 3300 -6840 {lab=B4bar}
N 3240 -6700 3300 -6700 {lab=B4bar}
N 3240 -6560 3300 -6560 {lab=B4bar}
N 3240 -6420 3300 -6420 {lab=B4bar}
N 3240 -6280 3300 -6280 {lab=B4bar}
N 3240 -6140 3300 -6140 {lab=B4bar}
N 3240 -6000 3300 -6000 {lab=B4bar}
N 3240 -8100 3300 -8100 {lab=B4bar}
N 3240 -7960 3300 -7960 {lab=B4bar}
N 3240 -7820 3300 -7820 {lab=B4bar}
N 3240 -7680 3300 -7680 {lab=B4bar}
N 3240 -7540 3300 -7540 {lab=B4bar}
N 3240 -7400 3300 -7400 {lab=B4bar}
N 3240 -7260 3300 -7260 {lab=B4bar}
N 3240 -7120 3300 -7120 {lab=B4bar}
N 5200 -6980 5260 -6980 {lab=B4bar_h}
N 5200 -6840 5260 -6840 {lab=B4bar_h}
N 5200 -6700 5260 -6700 {lab=B4bar_h}
N 5200 -6560 5260 -6560 {lab=B4bar_h}
N 5200 -6420 5260 -6420 {lab=B4bar_h}
N 5200 -6280 5260 -6280 {lab=B4bar_h}
N 5200 -6140 5260 -6140 {lab=B4bar_h}
N 5200 -6000 5260 -6000 {lab=B4bar_h}
N 5200 -8100 5260 -8100 {lab=B4bar_h}
N 5200 -7960 5260 -7960 {lab=B4bar_h}
N 5200 -7820 5260 -7820 {lab=B4bar_h}
N 5200 -7680 5260 -7680 {lab=B4bar_h}
N 5200 -7540 5260 -7540 {lab=B4bar_h}
N 5200 -7400 5260 -7400 {lab=B4bar_h}
N 5200 -7260 5260 -7260 {lab=B4bar_h}
N 5200 -7120 5260 -7120 {lab=B4bar_h}
N 3840 -10340 3840 -10320 {lab=VDD}
N 3640 -10340 3640 -10320 {lab=VDD}
N 3440 -10340 3440 -10320 {lab=VDD}
N 3240 -10340 3240 -10320 {lab=VDD}
N 2510 -10170 4000 -10170 {lab=IN0}
N 2510 -10030 3800 -10030 {lab=IN1}
N 4000 -9950 4000 -9890 {lab=IN2}
N 3800 -9950 3800 -9890 {lab=IN2}
N 2510 -9950 4000 -9950 {lab=IN2}
N 3600 -9810 3600 -9750 {lab=IN3}
N 3600 -9670 3600 -9610 {lab=IN4}
N 3600 -9530 3600 -9470 {lab=IN5}
N 3600 -9390 3600 -9330 {lab=IN6}
N 3600 -8690 3600 -8630 {lab=IN11}
N 3600 -8550 3600 -8490 {lab=IN12}
N 3600 -8410 3600 -8350 {lab=IN13}
N 3600 -8270 3600 -8210 {lab=IN14}
N 3600 -7570 3600 -7510 {lab=IN19}
N 3600 -7430 3600 -7370 {lab=IN20}
N 3600 -7290 3600 -7230 {lab=IN21}
N 3600 -7150 3600 -7090 {lab=IN22}
N 3600 -6450 3600 -6390 {lab=IN27}
N 3600 -6310 3600 -6250 {lab=IN28}
N 3600 -6170 3600 -6110 {lab=IN29}
N 3600 -6030 3600 -5970 {lab=IN30}
N 4900 -9810 4900 -9750 {lab=IN35}
N 4900 -9670 4900 -9610 {lab=IN36}
N 4900 -9530 4900 -9470 {lab=IN37}
N 4900 -9390 4900 -9330 {lab=IN38}
N 4900 -8690 4900 -8630 {lab=IN43}
N 4900 -8550 4900 -8490 {lab=IN44}
N 4900 -8410 4900 -8350 {lab=IN45}
N 4900 -8270 4900 -8210 {lab=IN46}
N 4900 -7570 4900 -7510 {lab=IN51}
N 4900 -7430 4900 -7370 {lab=IN52}
N 4900 -7290 4900 -7230 {lab=IN53}
N 4900 -7150 4900 -7090 {lab=IN54}
N 4900 -6450 4900 -6390 {lab=IN59}
N 4900 -6310 4900 -6250 {lab=IN60}
N 4900 -6170 4900 -6110 {lab=IN61}
N 4900 -6030 4900 -5970 {lab=IN62}
N 5100 -6450 5100 -6390 {lab=IN59}
N 5100 -6310 5100 -6250 {lab=IN60}
N 5100 -6170 5100 -6110 {lab=IN61}
N 5100 -6030 5100 -5970 {lab=IN62}
N 5100 -7010 5100 -6950 {lab=IN55}
N 5100 -6870 5100 -6810 {lab=IN56}
N 5100 -6730 5100 -6670 {lab=IN57}
N 5100 -6590 5100 -6530 {lab=IN58}
N 5100 -8690 5100 -8630 {lab=IN43}
N 5100 -8550 5100 -8490 {lab=IN44}
N 5100 -8410 5100 -8350 {lab=IN45}
N 5100 -8270 5100 -8210 {lab=IN46}
N 5100 -9250 5100 -9190 {lab=IN39}
N 5100 -9110 5100 -9050 {lab=IN40}
N 5100 -8970 5100 -8910 {lab=IN41}
N 5100 -8830 5100 -8770 {lab=IN42}
N 4000 -9670 4000 -9610 {lab=IN4}
N 4000 -9390 4000 -9330 {lab=IN6}
N 4000 -9110 4000 -9050 {lab=IN8}
N 4000 -8830 4000 -8770 {lab=IN10}
N 4000 -8550 4000 -8490 {lab=IN12}
N 4000 -8270 4000 -8210 {lab=IN14}
N 4000 -7990 4000 -7930 {lab=IN16}
N 4000 -7710 4000 -7650 {lab=IN18}
N 4000 -7430 4000 -7370 {lab=IN20}
N 4000 -7150 4000 -7090 {lab=IN22}
N 4000 -6870 4000 -6810 {lab=IN24}
N 4000 -6590 4000 -6530 {lab=IN26}
N 4000 -6310 4000 -6250 {lab=IN28}
N 4000 -6030 4000 -5970 {lab=IN30}
N 4500 -10230 4500 -10170 {lab=IN32}
N 4500 -9950 4500 -9890 {lab=IN34}
N 4500 -9670 4500 -9610 {lab=IN36}
N 4500 -9390 4500 -9330 {lab=IN38}
N 4500 -9110 4500 -9050 {lab=IN40}
N 4500 -8830 4500 -8770 {lab=IN42}
N 4500 -8550 4500 -8490 {lab=IN44}
N 4500 -8270 4500 -8210 {lab=IN46}
N 4500 -7990 4500 -7930 {lab=IN48}
N 4500 -7710 4500 -7650 {lab=IN50}
N 4500 -7430 4500 -7370 {lab=IN52}
N 4500 -7150 4500 -7090 {lab=IN54}
N 4500 -6870 4500 -6810 {lab=IN56}
N 4500 -6590 4500 -6530 {lab=IN58}
N 4500 -6310 4500 -6250 {lab=IN60}
N 4500 -6030 4500 -5970 {lab=IN62}
N 3400 -6450 3400 -6390 {lab=IN27}
N 3400 -6310 3400 -6250 {lab=IN28}
N 3400 -6170 3400 -6110 {lab=IN29}
N 3400 -6030 3400 -5970 {lab=IN30}
N 3400 -7010 3400 -6950 {lab=IN23}
N 3400 -6870 3400 -6810 {lab=IN24}
N 3400 -6730 3400 -6670 {lab=IN25}
N 3400 -6590 3400 -6530 {lab=IN26}
N 3400 -8690 3400 -8630 {lab=IN11}
N 3400 -8550 3400 -8490 {lab=IN12}
N 3400 -8410 3400 -8350 {lab=IN13}
N 3400 -8270 3400 -8210 {lab=IN14}
N 3400 -9250 3400 -9190 {lab=IN7}
N 3400 -9110 3400 -9050 {lab=IN8}
N 3400 -8970 3400 -8910 {lab=IN9}
N 3400 -8830 3400 -8770 {lab=IN10}
N 3200 -7570 3200 -7510 {lab=IN19}
N 3200 -7430 3200 -7370 {lab=IN20}
N 3200 -7290 3200 -7230 {lab=IN21}
N 3200 -7150 3200 -7090 {lab=IN22}
N 3200 -8130 3200 -8070 {lab=IN15}
N 3200 -7990 3200 -7930 {lab=IN16}
N 3200 -7850 3200 -7790 {lab=IN17}
N 3200 -7710 3200 -7650 {lab=IN18}
N 3200 -6450 3200 -6390 {lab=IN27}
N 3200 -6310 3200 -6250 {lab=IN28}
N 3200 -6170 3200 -6110 {lab=IN29}
N 3200 -6030 3200 -5970 {lab=IN30}
N 3200 -7010 3200 -6950 {lab=IN23}
N 3200 -6870 3200 -6810 {lab=IN24}
N 3200 -6730 3200 -6670 {lab=IN25}
N 3200 -6590 3200 -6530 {lab=IN26}
N 5300 -7570 5300 -7510 {lab=IN51}
N 5300 -7430 5300 -7370 {lab=IN52}
N 5300 -7290 5300 -7230 {lab=IN53}
N 5300 -7150 5300 -7090 {lab=IN54}
N 5300 -8130 5300 -8070 {lab=IN47}
N 5300 -7990 5300 -7930 {lab=IN48}
N 5300 -7850 5300 -7790 {lab=IN49}
N 5300 -7710 5300 -7650 {lab=IN50}
N 5300 -6450 5300 -6390 {lab=IN59}
N 5300 -6310 5300 -6250 {lab=IN60}
N 5300 -6170 5300 -6110 {lab=IN61}
N 5300 -6030 5300 -5970 {lab=IN62}
N 5300 -7010 5300 -6950 {lab=IN55}
N 5300 -6870 5300 -6810 {lab=IN56}
N 5300 -6730 5300 -6670 {lab=IN57}
N 5300 -6590 5300 -6530 {lab=IN58}
N 4700 -8410 4700 -8350 {lab=IN45}
N 4700 -8270 4700 -8210 {lab=IN46}
N 4700 -8970 4700 -8910 {lab=IN41}
N 4700 -8830 4700 -8770 {lab=IN42}
N 4700 -9530 4700 -9470 {lab=IN37}
N 4700 -9390 4700 -9330 {lab=IN38}
N 3800 -6170 3800 -6110 {lab=IN29}
N 3800 -6030 3800 -5970 {lab=IN30}
N 3800 -6730 3800 -6670 {lab=IN25}
N 3800 -6590 3800 -6530 {lab=IN26}
N 3800 -7290 3800 -7230 {lab=IN21}
N 3800 -7150 3800 -7090 {lab=IN22}
N 3800 -7850 3800 -7790 {lab=IN17}
N 3800 -7710 3800 -7650 {lab=IN18}
N 3800 -8410 3800 -8350 {lab=IN13}
N 3800 -8270 3800 -8210 {lab=IN14}
N 3800 -8970 3800 -8910 {lab=IN9}
N 3800 -8830 3800 -8770 {lab=IN10}
N 4700 -6170 4700 -6110 {lab=IN61}
N 4700 -6030 4700 -5970 {lab=IN62}
N 4700 -6730 4700 -6670 {lab=IN57}
N 4700 -6590 4700 -6530 {lab=IN58}
N 4700 -7290 4700 -7230 {lab=IN53}
N 4700 -7150 4700 -7090 {lab=IN54}
N 4700 -7850 4700 -7790 {lab=IN49}
N 4700 -7710 4700 -7650 {lab=IN50}
N 4700 -10090 4700 -10030 {lab=IN33}
N 4700 -9950 4700 -9890 {lab=IN34}
N 3800 -9530 3800 -9470 {lab=IN5}
N 3800 -9390 3800 -9330 {lab=IN6}
N 2500 -9810 3990 -9810 {lab=IN3}
N 2510 -9670 4000 -9670 {lab=IN4}
N 2510 -9530 4000 -9530 {lab=IN5}
N 2510 -9390 4000 -9390 {lab=IN6}
N 2520 -9250 4010 -9250 {lab=IN7}
N 2520 -9110 4010 -9110 {lab=IN8}
N 2510 -8970 4000 -8970 {lab=IN9}
N 2520 -8830 4010 -8830 {lab=IN10}
N 2520 -8690 4010 -8690 {lab=IN11}
N 2510 -8550 4000 -8550 {lab=IN12}
N 2520 -8410 4010 -8410 {lab=IN13}
N 2520 -8270 4010 -8270 {lab=IN14}
N 2500 -8130 3990 -8130 {lab=IN15}
N 2510 -7990 4000 -7990 {lab=IN16}
N 2510 -7850 4000 -7850 {lab=IN17}
N 2510 -7710 4000 -7710 {lab=IN18}
N 2520 -7570 4010 -7570 {lab=IN19}
N 2520 -7430 4010 -7430 {lab=IN20}
N 2500 -7290 3990 -7290 {lab=IN21}
N 2510 -7150 4000 -7150 {lab=IN22}
N 2510 -7010 4000 -7010 {lab=IN23}
N 2510 -6870 4000 -6870 {lab=IN24}
N 2510 -6730 4000 -6730 {lab=IN25}
N 2520 -6590 4010 -6590 {lab=IN26}
N 2520 -6450 4010 -6450 {lab=IN27}
N 2510 -6310 4000 -6310 {lab=IN28}
N 2520 -6170 4010 -6170 {lab=IN29}
N 2520 -6030 4010 -6030 {lab=IN30}
N 4490 -10230 5980 -10230 {lab=IN32}
N 4490 -10090 5980 -10090 {lab=IN33}
N 4510 -9950 6000 -9950 {lab=IN34}
N 4500 -9810 5990 -9810 {lab=IN35}
N 4500 -9670 5990 -9670 {lab=IN36}
N 4500 -9530 5990 -9530 {lab=IN37}
N 4490 -9390 5980 -9390 {lab=IN38}
N 4490 -9250 5980 -9250 {lab=IN39}
N 4510 -9110 6000 -9110 {lab=IN40}
N 4500 -8970 5990 -8970 {lab=IN41}
N 4500 -8830 5990 -8830 {lab=IN42}
N 4500 -8690 5990 -8690 {lab=IN43}
N 4500 -8550 5990 -8550 {lab=IN44}
N 4490 -8410 5980 -8410 {lab=IN45}
N 4490 -8270 5980 -8270 {lab=IN46}
N 4500 -8130 5990 -8130 {lab=IN47}
N 4490 -7990 5980 -7990 {lab=IN48}
N 4490 -7850 5980 -7850 {lab=IN49}
N 4500 -7710 5990 -7710 {lab=IN50}
N 4490 -7570 5980 -7570 {lab=IN51}
N 4490 -7430 5980 -7430 {lab=IN52}
N 4510 -7290 6000 -7290 {lab=IN53}
N 4500 -7150 5990 -7150 {lab=IN54}
N 4500 -7010 5990 -7010 {lab=IN55}
N 4500 -6870 5990 -6870 {lab=IN56}
N 4490 -6730 5980 -6730 {lab=IN57}
N 4490 -6590 5980 -6590 {lab=IN58}
N 4510 -6450 6000 -6450 {lab=IN59}
N 4500 -6310 5990 -6310 {lab=IN60}
N 4500 -6170 5990 -6170 {lab=IN61}
N 4500 -6030 5990 -6030 {lab=IN62}
N 4040 -6000 4100 -6000 {lab=B0bar}
N 4500 -9950 4510 -9950 {lab=IN34}
N 4500 -9110 4510 -9110 {lab=IN40}
N 3560 -4840 3560 -4760 {lab=B4bar_mux}
N 3560 -4840 3630 -4840 {lab=B4bar_mux}
N 3560 -4760 3560 -4690 {lab=B4bar_mux}
N 3560 -4690 3630 -4690 {lab=B4bar_mux}
N 3670 -4810 3670 -4720 {lab=B4}
N 3670 -4760 3780 -4760 {lab=B4}
N 3670 -4660 3670 -4640 {lab=GND}
N 3670 -4890 3670 -4870 {lab=VDD}
N 3520 -4760 3560 -4760 {lab=B4bar_mux}
N 3665 -4840 3680 -4840 {lab=VDD}
N 3670 -4690 3690 -4690 {lab=GND}
N 3870 -4840 3870 -4760 {lab=B3bar_mux}
N 3870 -4840 3940 -4840 {lab=B3bar_mux}
N 3870 -4760 3870 -4690 {lab=B3bar_mux}
N 3870 -4690 3940 -4690 {lab=B3bar_mux}
N 3980 -4810 3980 -4720 {lab=B3}
N 3980 -4760 4090 -4760 {lab=B3}
N 3980 -4660 3980 -4640 {lab=GND}
N 3980 -4890 3980 -4870 {lab=VDD}
N 3830 -4760 3870 -4760 {lab=B3bar_mux}
N 3975 -4840 3990 -4840 {lab=VDD}
N 3980 -4690 4000 -4690 {lab=GND}
N 4190 -4840 4190 -4760 {lab=B2bar_mux}
N 4190 -4840 4260 -4840 {lab=B2bar_mux}
N 4190 -4760 4190 -4690 {lab=B2bar_mux}
N 4190 -4690 4260 -4690 {lab=B2bar_mux}
N 4300 -4810 4300 -4720 {lab=B2}
N 4300 -4760 4410 -4760 {lab=B2}
N 4300 -4660 4300 -4640 {lab=GND}
N 4300 -4890 4300 -4870 {lab=VDD}
N 4150 -4760 4190 -4760 {lab=B2bar_mux}
N 4295 -4840 4310 -4840 {lab=VDD}
N 4300 -4690 4320 -4690 {lab=GND}
N 4510 -4840 4510 -4760 {lab=B1bar_mux}
N 4510 -4840 4580 -4840 {lab=B1bar_mux}
N 4510 -4760 4510 -4690 {lab=B1bar_mux}
N 4510 -4690 4580 -4690 {lab=B1bar_mux}
N 4620 -4810 4620 -4720 {lab=B1}
N 4620 -4760 4730 -4760 {lab=B1}
N 4620 -4660 4620 -4640 {lab=GND}
N 4620 -4890 4620 -4870 {lab=VDD}
N 4470 -4760 4510 -4760 {lab=B1bar_mux}
N 4615 -4840 4630 -4840 {lab=VDD}
N 4620 -4690 4640 -4690 {lab=GND}
N 4830 -4840 4830 -4760 {lab=B0bar_mux}
N 4830 -4840 4900 -4840 {lab=B0bar_mux}
N 4830 -4760 4830 -4690 {lab=B0bar_mux}
N 4830 -4690 4900 -4690 {lab=B0bar_mux}
N 4940 -4810 4940 -4720 {lab=B0}
N 4940 -4760 5050 -4760 {lab=B0}
N 4940 -4660 4940 -4640 {lab=GND}
N 4940 -4890 4940 -4870 {lab=VDD}
N 4790 -4760 4830 -4760 {lab=B0bar_mux}
N 4935 -4840 4950 -4840 {lab=VDD}
N 4940 -4690 4960 -4690 {lab=GND}
N 3240 -10400 3300 -10400 {lab=VDD}
N 3240 -10400 3240 -10340 {lab=VDD}
N 3440 -10400 3500 -10400 {lab=VDD}
N 3440 -10400 3440 -10340 {lab=VDD}
N 3640 -10400 3700 -10400 {lab=VDD}
N 3640 -10400 3640 -10340 {lab=VDD}
N 3840 -10400 3900 -10400 {lab=VDD}
N 3840 -10400 3840 -10340 {lab=VDD}
N 4040 -10400 4100 -10400 {lab=VDD}
N 4040 -10400 4040 -10340 {lab=VDD}
N 3300 -10340 3300 -10260 {lab=B4bar}
N 3500 -10340 3500 -10260 {lab=B3bar}
N 3700 -10340 3700 -10260 {lab=B2bar}
N 3900 -10340 3900 -10260 {lab=B1bar}
N 4100 -10340 4100 -10260 {lab=B0bar}
N 4460 -10340 4460 -10320 {lab=VDD}
N 4660 -10340 4660 -10320 {lab=VDD}
N 4860 -10340 4860 -10320 {lab=VDD}
N 5060 -10340 5060 -10320 {lab=VDD}
N 5260 -10340 5260 -10320 {lab=VDD}
N 5200 -10400 5260 -10400 {lab=VDD}
N 5260 -10400 5260 -10340 {lab=VDD}
N 5000 -10400 5060 -10400 {lab=VDD}
N 5060 -10400 5060 -10340 {lab=VDD}
N 4800 -10400 4860 -10400 {lab=VDD}
N 4860 -10400 4860 -10340 {lab=VDD}
N 4600 -10400 4660 -10400 {lab=VDD}
N 4660 -10400 4660 -10340 {lab=VDD}
N 4400 -10400 4460 -10400 {lab=VDD}
N 4460 -10400 4460 -10340 {lab=VDD}
N 5200 -10340 5200 -10260 {lab=B4bar_h}
N 5000 -10340 5000 -10260 {lab=B3bar_h}
N 4800 -10340 4800 -10260 {lab=B2bar_h}
N 4600 -10340 4600 -10260 {lab=B1bar_h}
N 4400 -10340 4400 -10260 {lab=B0bar_h}
N 3760 -5700 3760 -5540 {lab=B4bar_mux}
N 3700 -5700 3700 -5540 {lab=B4bar_h}
N 3580 -5620 3700 -5620 {lab=B4bar_h}
N 3760 -5620 3820 -5620 {lab=B4bar_mux}
N 4180 -5700 4180 -5540 {lab=B3bar_mux}
N 4120 -5700 4120 -5540 {lab=B3bar_h}
N 4000 -5620 4120 -5620 {lab=B3bar_h}
N 4180 -5620 4240 -5620 {lab=B3bar_mux}
N 4560 -5700 4560 -5540 {lab=B2bar_mux}
N 4500 -5700 4500 -5540 {lab=B2bar_h}
N 4380 -5620 4500 -5620 {lab=B2bar_h}
N 4560 -5620 4620 -5620 {lab=B2bar_mux}
N 4940 -5700 4940 -5540 {lab=B1bar_mux}
N 4880 -5700 4880 -5540 {lab=B1bar_h}
N 4760 -5620 4880 -5620 {lab=B1bar_h}
N 4940 -5620 5000 -5620 {lab=B1bar_mux}
N 5280 -5700 5280 -5540 {lab=B0bar_mux}
N 5220 -5700 5220 -5540 {lab=B0bar_h}
N 5100 -5620 5220 -5620 {lab=B0bar_h}
N 5280 -5620 5340 -5620 {lab=B0bar_mux}
N 3760 -5360 3760 -5200 {lab=B4bar_mux}
N 3700 -5360 3700 -5200 {lab=B4bar}
N 3580 -5280 3700 -5280 {lab=B4bar}
N 3760 -5280 3820 -5280 {lab=B4bar_mux}
N 4180 -5360 4180 -5200 {lab=B3bar_mux}
N 4120 -5360 4120 -5200 {lab=B3bar}
N 4000 -5280 4120 -5280 {lab=B3bar}
N 4180 -5280 4240 -5280 {lab=B3bar_mux}
N 4560 -5360 4560 -5200 {lab=B2bar_mux}
N 4500 -5360 4500 -5200 {lab=B2bar}
N 4380 -5280 4500 -5280 {lab=B2bar}
N 4560 -5280 4620 -5280 {lab=B2bar_mux}
N 4940 -5360 4940 -5200 {lab=B1bar_mux}
N 4880 -5360 4880 -5200 {lab=B1bar}
N 4760 -5280 4880 -5280 {lab=B1bar}
N 4940 -5280 5000 -5280 {lab=B1bar_mux}
N 5280 -5360 5280 -5200 {lab=B0bar_mux}
N 5220 -5360 5220 -5200 {lab=B0bar}
N 5100 -5280 5220 -5280 {lab=B0bar}
N 5280 -5280 5340 -5280 {lab=B0bar_mux}
N 3160 -5420 3160 -5340 {lab=THERMOMETER_31}
N 3160 -5420 3230 -5420 {lab=THERMOMETER_31}
N 3160 -5340 3160 -5270 {lab=THERMOMETER_31}
N 3160 -5270 3230 -5270 {lab=THERMOMETER_31}
N 3270 -5390 3270 -5300 {lab=THERMOMETER_31bar}
N 3270 -5240 3270 -5220 {lab=GND}
N 3270 -5470 3270 -5450 {lab=VDD}
N 3020 -5340 3160 -5340 {lab=THERMOMETER_31}
N 3265 -5420 3280 -5420 {lab=VDD}
N 3270 -5270 3290 -5270 {lab=GND}
N 3270 -5340 3320 -5340 {lab=THERMOMETER_31bar}
N 3300 -10260 3300 -5860 {lab=B4bar}
N 3500 -10260 3500 -5860 {lab=B3bar}
N 3700 -10260 3700 -5860 {lab=B2bar}
N 3900 -10260 3900 -5860 {lab=B1bar}
N 4100 -10260 4100 -5860 {lab=B0bar}
N 4400 -10260 4400 -5860 {lab=B0bar_h}
N 4600 -10260 4600 -5860 {lab=B1bar_h}
N 4800 -10260 4800 -5860 {lab=B2bar_h}
N 5000 -10260 5000 -5860 {lab=B3bar_h}
N 5200 -10260 5200 -5860 {lab=B4bar_h}
N 3000 -5600 3060 -5600 {lab=THERMOMETER_31}
N 3120 -5600 3160 -5600 {lab=B5}
C {lab_wire.sym} 4040 -10340 0 0 {name=p526 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 4040 -10130 0 0 {name=p528 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -10170 0 0 {name=M218
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -10170 0 0 {name=p529 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -9850 0 0 {name=p530 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -9890 0 0 {name=M219
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -9890 0 0 {name=p531 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -9570 0 0 {name=p532 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -9610 0 0 {name=M220
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -9610 0 0 {name=p533 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -9850 0 0 {name=p534 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -9890 0 0 {name=M221
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -9890 0 0 {name=p535 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3840 -9990 0 0 {name=p536 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -10030 0 0 {name=M222
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -10030 0 0 {name=p537 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3840 -9430 0 0 {name=p538 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -9470 0 0 {name=M223
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -9470 0 0 {name=p539 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -9290 0 0 {name=p540 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -9330 0 0 {name=M224
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -9330 0 0 {name=p541 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -9290 0 0 {name=p542 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -9330 0 0 {name=M225
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -9330 0 0 {name=p543 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -9570 0 0 {name=p544 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -9610 0 0 {name=M226
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -9610 0 0 {name=p545 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -9710 0 0 {name=p546 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -9750 0 0 {name=M227
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -9750 0 0 {name=p547 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -9290 0 0 {name=p548 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -9330 0 0 {name=M228
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -9330 0 0 {name=p549 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -9430 0 0 {name=p550 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -9470 0 0 {name=M229
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -9470 0 0 {name=p551 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -9010 0 0 {name=p552 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -9050 0 0 {name=M230
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -9050 0 0 {name=p553 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -8730 0 0 {name=p554 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -8770 0 0 {name=M231
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -8770 0 0 {name=p555 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4040 -8450 0 0 {name=p556 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -8490 0 0 {name=M232
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -8490 0 0 {name=p557 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3840 -8730 0 0 {name=p558 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -8770 0 0 {name=M233
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -8770 0 0 {name=p559 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -8870 0 0 {name=p560 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -8910 0 0 {name=M234
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -8910 0 0 {name=p561 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -8310 0 0 {name=p562 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -8350 0 0 {name=M235
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -8350 0 0 {name=p563 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -8170 0 0 {name=p564 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -8210 0 0 {name=M236
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -8210 0 0 {name=p565 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -8170 0 0 {name=p566 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -8210 0 0 {name=M237
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -8210 0 0 {name=p567 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -8450 0 0 {name=p568 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -8490 0 0 {name=M238
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -8490 0 0 {name=p569 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -8590 0 0 {name=p570 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -8630 0 0 {name=M239
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -8630 0 0 {name=p571 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -8170 0 0 {name=p572 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -8210 0 0 {name=M240
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -8210 0 0 {name=p573 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -8310 0 0 {name=p574 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -8350 0 0 {name=M241
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -8350 0 0 {name=p575 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -9010 0 0 {name=p576 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -9050 0 0 {name=M242
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -9050 0 0 {name=p577 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -9150 0 0 {name=p578 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -9190 0 0 {name=M243
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -9190 0 0 {name=p579 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -8730 0 0 {name=p580 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -8770 0 0 {name=M244
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -8770 0 0 {name=p581 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -8870 0 0 {name=p582 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -8910 0 0 {name=M245
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -8910 0 0 {name=p583 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -8450 0 0 {name=p584 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -8490 0 0 {name=M246
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -8490 0 0 {name=p585 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -8590 0 0 {name=p586 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -8630 0 0 {name=M247
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -8630 0 0 {name=p587 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -8170 0 0 {name=p588 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -8210 0 0 {name=M248
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -8210 0 0 {name=p589 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -8310 0 0 {name=p590 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -8350 0 0 {name=M249
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -8350 0 0 {name=p591 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -8030 0 0 {name=p592 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -8070 0 0 {name=M250
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -8070 0 0 {name=p593 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -7890 0 0 {name=p594 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -7930 0 0 {name=M251
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -7930 0 0 {name=p595 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -7610 0 0 {name=p596 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -7650 0 0 {name=M252
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -7650 0 0 {name=p597 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -7330 0 0 {name=p598 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -7370 0 0 {name=M253
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -7370 0 0 {name=p599 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -7610 0 0 {name=p600 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -7650 0 0 {name=M254
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -7650 0 0 {name=p601 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -7750 0 0 {name=p602 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -7790 0 0 {name=M255
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -7790 0 0 {name=p603 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -7190 0 0 {name=p604 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -7230 0 0 {name=M256
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -7230 0 0 {name=p605 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -7050 0 0 {name=p606 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -7090 0 0 {name=M257
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -7090 0 0 {name=p607 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -7050 0 0 {name=p608 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -7090 0 0 {name=M258
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -7090 0 0 {name=p609 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -7330 0 0 {name=p610 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -7370 0 0 {name=M259
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -7370 0 0 {name=p611 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -7470 0 0 {name=p612 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -7510 0 0 {name=M260
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -7510 0 0 {name=p613 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -7050 0 0 {name=p614 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -7090 0 0 {name=M261
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -7090 0 0 {name=p615 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -7190 0 0 {name=p616 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -7230 0 0 {name=M262
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -7230 0 0 {name=p617 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -6770 0 0 {name=p618 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -6810 0 0 {name=M263
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -6810 0 0 {name=p619 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -6490 0 0 {name=p620 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -6530 0 0 {name=M264
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -6530 0 0 {name=p621 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -6210 0 0 {name=p622 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -6250 0 0 {name=M265
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -6250 0 0 {name=p623 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -6490 0 0 {name=p624 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -6530 0 0 {name=M266
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -6530 0 0 {name=p625 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -6630 0 0 {name=p626 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -6670 0 0 {name=M267
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -6670 0 0 {name=p627 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -6070 0 0 {name=p628 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -6110 0 0 {name=M268
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -6110 0 0 {name=p629 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4040 -5930 0 0 {name=p630 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4020 -5970 0 0 {name=M269
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4055 -5970 0 0 {name=p631 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -5930 0 0 {name=p632 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 3820 -5970 0 0 {name=M270
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3855 -5970 0 0 {name=p633 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -6210 0 0 {name=p634 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -6250 0 0 {name=M271
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -6250 0 0 {name=p635 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -6350 0 0 {name=p636 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -6390 0 0 {name=M272
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -6390 0 0 {name=p637 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -5930 0 0 {name=p638 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -5970 0 0 {name=M273
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -5970 0 0 {name=p639 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3640 -6070 0 0 {name=p640 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 3620 -6110 0 0 {name=M274
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3655 -6110 0 0 {name=p641 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -6770 0 0 {name=p642 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -6810 0 0 {name=M275
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -6810 0 0 {name=p643 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -6910 0 0 {name=p644 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -6950 0 0 {name=M276
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -6950 0 0 {name=p645 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -6490 0 0 {name=p646 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -6530 0 0 {name=M277
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -6530 0 0 {name=p647 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -6630 0 0 {name=p648 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -6670 0 0 {name=M278
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -6670 0 0 {name=p649 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -6210 0 0 {name=p650 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -6250 0 0 {name=M279
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -6250 0 0 {name=p651 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -6350 0 0 {name=p652 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -6390 0 0 {name=M280
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -6390 0 0 {name=p653 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -5930 0 0 {name=p654 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -5970 0 0 {name=M281
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -5970 0 0 {name=p655 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3440 -6070 0 0 {name=p656 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 3420 -6110 0 0 {name=M282
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3455 -6110 0 0 {name=p657 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -10130 0 1 {name=p658 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -10170 0 1 {name=M283
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -10170 0 1 {name=p659 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -9850 0 1 {name=p660 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -9890 0 1 {name=M284
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -9890 0 1 {name=p661 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -9570 0 1 {name=p662 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -9610 0 1 {name=M285
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -9610 0 1 {name=p663 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -9850 0 1 {name=p664 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -9890 0 1 {name=M286
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -9890 0 1 {name=p665 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -9990 0 1 {name=p666 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -10030 0 1 {name=M287
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -10030 0 1 {name=p667 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -9430 0 1 {name=p668 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -9470 0 1 {name=M288
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -9470 0 1 {name=p669 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -9290 0 1 {name=p670 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -9330 0 1 {name=M289
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -9330 0 1 {name=p671 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -9290 0 1 {name=p672 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -9330 0 1 {name=M290
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -9330 0 1 {name=p673 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -9570 0 1 {name=p674 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -9610 0 1 {name=M291
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -9610 0 1 {name=p675 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -9710 0 1 {name=p676 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -9750 0 1 {name=M292
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -9750 0 1 {name=p677 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -9290 0 1 {name=p678 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -9330 0 1 {name=M293
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -9330 0 1 {name=p679 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -9430 0 1 {name=p680 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -9470 0 1 {name=M294
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -9470 0 1 {name=p681 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -9010 0 1 {name=p682 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -9050 0 1 {name=M295
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -9050 0 1 {name=p683 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -8730 0 1 {name=p684 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -8770 0 1 {name=M296
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -8770 0 1 {name=p685 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -8450 0 1 {name=p686 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -8490 0 1 {name=M297
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -8490 0 1 {name=p687 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4660 -8730 0 1 {name=p688 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -8770 0 1 {name=M298
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -8770 0 1 {name=p689 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -8870 0 1 {name=p690 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -8910 0 1 {name=M299
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -8910 0 1 {name=p691 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -8310 0 1 {name=p692 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -8350 0 1 {name=M300
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -8350 0 1 {name=p693 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -8170 0 1 {name=p694 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -8210 0 1 {name=M301
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -8210 0 1 {name=p695 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -8170 0 1 {name=p696 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -8210 0 1 {name=M302
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -8210 0 1 {name=p697 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -8450 0 1 {name=p698 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -8490 0 1 {name=M303
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -8490 0 1 {name=p699 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -8590 0 1 {name=p700 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -8630 0 1 {name=M304
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -8630 0 1 {name=p701 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -8170 0 1 {name=p702 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -8210 0 1 {name=M305
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -8210 0 1 {name=p703 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -8310 0 1 {name=p704 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -8350 0 1 {name=M306
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -8350 0 1 {name=p705 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -9010 0 1 {name=p706 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -9050 0 1 {name=M307
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -9050 0 1 {name=p707 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -9150 0 1 {name=p708 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -9190 0 1 {name=M308
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -9190 0 1 {name=p709 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -8730 0 1 {name=p710 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -8770 0 1 {name=M309
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -8770 0 1 {name=p711 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -8870 0 1 {name=p712 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -8910 0 1 {name=M310
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -8910 0 1 {name=p713 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -8450 0 1 {name=p714 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -8490 0 1 {name=M311
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -8490 0 1 {name=p715 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -8590 0 1 {name=p716 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -8630 0 1 {name=M312
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -8630 0 1 {name=p717 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -8170 0 1 {name=p718 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -8210 0 1 {name=M313
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -8210 0 1 {name=p719 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -8310 0 1 {name=p720 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -8350 0 1 {name=M314
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -8350 0 1 {name=p721 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -7890 0 1 {name=p722 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -7930 0 1 {name=M315
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -7930 0 1 {name=p723 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -7610 0 1 {name=p724 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -7650 0 1 {name=M316
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -7650 0 1 {name=p725 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -7330 0 1 {name=p726 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -7370 0 1 {name=M317
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -7370 0 1 {name=p727 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -7610 0 1 {name=p728 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -7650 0 1 {name=M318
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -7650 0 1 {name=p729 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -7750 0 1 {name=p730 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -7790 0 1 {name=M319
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -7790 0 1 {name=p731 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -7190 0 1 {name=p732 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -7230 0 1 {name=M320
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -7230 0 1 {name=p733 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -7050 0 1 {name=p734 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -7090 0 1 {name=M321
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -7090 0 1 {name=p735 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -7050 0 1 {name=p736 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -7090 0 1 {name=M322
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -7090 0 1 {name=p737 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -7330 0 1 {name=p738 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -7370 0 1 {name=M323
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -7370 0 1 {name=p739 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -7470 0 1 {name=p740 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -7510 0 1 {name=M324
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -7510 0 1 {name=p741 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -7050 0 1 {name=p742 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -7090 0 1 {name=M325
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -7090 0 1 {name=p743 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -7190 0 1 {name=p744 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -7230 0 1 {name=M326
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -7230 0 1 {name=p745 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -6770 0 1 {name=p746 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -6810 0 1 {name=M327
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -6810 0 1 {name=p747 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -6490 0 1 {name=p748 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -6530 0 1 {name=M328
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -6530 0 1 {name=p749 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -6210 0 1 {name=p750 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -6250 0 1 {name=M329
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -6250 0 1 {name=p751 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -6490 0 1 {name=p752 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -6530 0 1 {name=M330
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -6530 0 1 {name=p753 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -6630 0 1 {name=p754 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -6670 0 1 {name=M331
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -6670 0 1 {name=p755 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4660 -6070 0 1 {name=p756 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -6110 0 1 {name=M332
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -6110 0 1 {name=p757 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4460 -5930 0 1 {name=p758 sig_type=std_logic lab=GND
m=-6}
C {symbols/nfet_03v3.sym} 4480 -5970 0 1 {name=M333
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4445 -5970 0 1 {name=p759 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4660 -5930 0 1 {name=p760 sig_type=std_logic lab=GND
m=-5}
C {symbols/nfet_03v3.sym} 4680 -5970 0 1 {name=M334
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4645 -5970 0 1 {name=p761 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -6210 0 1 {name=p762 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -6250 0 1 {name=M335
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -6250 0 1 {name=p763 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -6350 0 1 {name=p764 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -6390 0 1 {name=M336
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -6390 0 1 {name=p765 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -5930 0 1 {name=p766 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -5970 0 1 {name=M337
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -5970 0 1 {name=p767 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 4860 -6070 0 1 {name=p768 sig_type=std_logic lab=GND
m=-4}
C {symbols/nfet_03v3.sym} 4880 -6110 0 1 {name=M338
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 4845 -6110 0 1 {name=p769 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -6770 0 1 {name=p770 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -6810 0 1 {name=M339
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -6810 0 1 {name=p771 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -6910 0 1 {name=p772 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -6950 0 1 {name=M340
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -6950 0 1 {name=p773 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -6490 0 1 {name=p774 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -6530 0 1 {name=M341
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -6530 0 1 {name=p775 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -6630 0 1 {name=p776 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -6670 0 1 {name=M342
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -6670 0 1 {name=p777 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -6210 0 1 {name=p778 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -6250 0 1 {name=M343
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -6250 0 1 {name=p779 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -6350 0 1 {name=p780 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -6390 0 1 {name=M344
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -6390 0 1 {name=p781 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -5930 0 1 {name=p782 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -5970 0 1 {name=M345
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -5970 0 1 {name=p783 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5060 -6070 0 1 {name=p784 sig_type=std_logic lab=GND
m=-3}
C {symbols/nfet_03v3.sym} 5080 -6110 0 1 {name=M346
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5045 -6110 0 1 {name=p785 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -7750 0 0 {name=p786 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -7790 0 0 {name=M347
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -7790 0 0 {name=p787 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -7890 0 0 {name=p788 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -7930 0 0 {name=M348
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -7930 0 0 {name=p789 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -7470 0 0 {name=p790 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -7510 0 0 {name=M349
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -7510 0 0 {name=p791 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -7610 0 0 {name=p792 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -7650 0 0 {name=M350
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -7650 0 0 {name=p793 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -7190 0 0 {name=p794 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -7230 0 0 {name=M351
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -7230 0 0 {name=p795 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -7330 0 0 {name=p796 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -7370 0 0 {name=M352
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -7370 0 0 {name=p797 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -7050 0 0 {name=p798 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -7090 0 0 {name=M353
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -7090 0 0 {name=p799 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -6910 0 0 {name=p800 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -6950 0 0 {name=M354
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -6950 0 0 {name=p801 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -6630 0 0 {name=p802 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -6670 0 0 {name=M355
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -6670 0 0 {name=p803 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -6770 0 0 {name=p804 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -6810 0 0 {name=M356
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -6810 0 0 {name=p805 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -6350 0 0 {name=p806 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -6390 0 0 {name=M357
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -6390 0 0 {name=p807 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -6490 0 0 {name=p808 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -6530 0 0 {name=M358
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -6530 0 0 {name=p809 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -6070 0 0 {name=p810 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -6110 0 0 {name=M359
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -6110 0 0 {name=p811 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -6210 0 0 {name=p812 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -6250 0 0 {name=M360
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -6250 0 0 {name=p813 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3240 -5930 0 0 {name=p814 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 3220 -5970 0 0 {name=M361
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 3255 -5970 0 0 {name=p815 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -8030 0 1 {name=p816 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -8070 0 1 {name=M362
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -8070 0 1 {name=p817 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -7750 0 1 {name=p818 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -7790 0 1 {name=M363
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -7790 0 1 {name=p819 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -7890 0 1 {name=p820 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -7930 0 1 {name=M364
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -7930 0 1 {name=p821 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -7470 0 1 {name=p822 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -7510 0 1 {name=M365
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -7510 0 1 {name=p823 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -7610 0 1 {name=p824 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -7650 0 1 {name=M366
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -7650 0 1 {name=p825 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -7190 0 1 {name=p826 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -7230 0 1 {name=M367
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -7230 0 1 {name=p827 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -7330 0 1 {name=p828 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -7370 0 1 {name=M368
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -7370 0 1 {name=p829 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -7050 0 1 {name=p830 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -7090 0 1 {name=M369
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -7090 0 1 {name=p831 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -6910 0 1 {name=p832 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -6950 0 1 {name=M370
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -6950 0 1 {name=p833 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -6630 0 1 {name=p834 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -6670 0 1 {name=M371
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -6670 0 1 {name=p835 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -6770 0 1 {name=p836 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -6810 0 1 {name=M372
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -6810 0 1 {name=p837 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -6350 0 1 {name=p838 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -6390 0 1 {name=M373
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -6390 0 1 {name=p839 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -6490 0 1 {name=p840 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -6530 0 1 {name=M374
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -6530 0 1 {name=p841 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -6070 0 1 {name=p842 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -6110 0 1 {name=M375
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -6110 0 1 {name=p843 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -6210 0 1 {name=p844 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -6250 0 1 {name=M376
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -6250 0 1 {name=p845 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 5260 -5930 0 1 {name=p846 sig_type=std_logic lab=GND
m=-2}
C {symbols/nfet_03v3.sym} 5280 -5970 0 1 {name=M377
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=nand}
C {lab_wire.sym} 5245 -5970 0 1 {name=p847 sig_type=std_logic lab=GND
m=1}
C {lab_wire.sym} 3840 -10340 0 0 {name=p912 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 3640 -10340 0 0 {name=p914 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 3440 -10340 0 0 {name=p916 sig_type=std_logic lab=VDD
m=55}
C {ipin.sym} 2510 -10170 0 0 {name=p950 lab=IN0}
C {ipin.sym} 2520 -10030 0 0 {name=p951 lab=IN1}
C {ipin.sym} 2520 -9950 0 0 {name=p952 lab=IN2}
C {ipin.sym} 2520 -9810 0 0 {name=p953 lab=IN3}
C {ipin.sym} 2510 -9670 0 0 {name=p954 lab=IN4
m=1}
C {ipin.sym} 2520 -9530 0 0 {name=p955 lab=IN5
m=1}
C {ipin.sym} 2530 -9390 0 0 {name=p956 lab=IN6
m=1}
C {ipin.sym} 2530 -9250 0 0 {name=p957 lab=IN7
m=1}
C {ipin.sym} 2540 -9110 0 0 {name=p958 lab=IN8
m=1}
C {ipin.sym} 2530 -8970 0 0 {name=p959 lab=IN9
m=1}
C {ipin.sym} 2540 -8830 0 0 {name=p960 lab=IN10
m=1}
C {ipin.sym} 2540 -8690 0 0 {name=p961 lab=IN11
m=1}
C {ipin.sym} 2550 -8550 0 0 {name=p962 lab=IN12
m=1}
C {ipin.sym} 2540 -8410 0 0 {name=p963 lab=IN13
m=1}
C {ipin.sym} 2550 -8270 0 0 {name=p964 lab=IN14
m=1}
C {ipin.sym} 2550 -8130 0 0 {name=p965 lab=IN15
m=1}
C {ipin.sym} 2560 -7990 0 0 {name=p966 lab=IN16
m=1}
C {ipin.sym} 2540 -7850 0 0 {name=p967 lab=IN17
m=1}
C {ipin.sym} 2550 -7710 0 0 {name=p968 lab=IN18
m=1}
C {ipin.sym} 2550 -7570 0 0 {name=p969 lab=IN19
m=1}
C {ipin.sym} 2560 -7430 0 0 {name=p970 lab=IN20
m=1}
C {ipin.sym} 2550 -7290 0 0 {name=p971 lab=IN21
m=1}
C {ipin.sym} 2560 -7150 0 0 {name=p972 lab=IN22
m=1}
C {ipin.sym} 2550 -7010 0 0 {name=p973 lab=IN23
m=1}
C {ipin.sym} 2560 -6870 0 0 {name=p974 lab=IN24
m=1}
C {ipin.sym} 2560 -6730 0 0 {name=p975 lab=IN25
m=1}
C {ipin.sym} 2570 -6590 0 0 {name=p976 lab=IN26
m=1}
C {ipin.sym} 2560 -6450 0 0 {name=p977 lab=IN27
m=1}
C {ipin.sym} 2570 -6310 0 0 {name=p978 lab=IN28
m=1}
C {ipin.sym} 2570 -6170 0 0 {name=p979 lab=IN29
m=1}
C {ipin.sym} 2580 -6030 0 0 {name=p980 lab=IN30
m=1}
C {ipin.sym} 5930 -10230 0 1 {name=p982 lab=IN32
m=1}
C {ipin.sym} 5940 -10090 0 1 {name=p983 lab=IN33
m=1}
C {ipin.sym} 5920 -9950 0 1 {name=p984 lab=IN34
m=1}
C {ipin.sym} 5920 -9810 0 1 {name=p985 lab=IN35
m=1}
C {ipin.sym} 5910 -9670 0 1 {name=p986 lab=IN36
m=1}
C {ipin.sym} 5920 -9530 0 1 {name=p987 lab=IN37
m=1}
C {ipin.sym} 5910 -9390 0 1 {name=p988 lab=IN38
m=1}
C {ipin.sym} 5910 -9250 0 1 {name=p989 lab=IN39
m=1}
C {ipin.sym} 5900 -9110 0 1 {name=p990 lab=IN40
m=1}
C {ipin.sym} 5910 -8970 0 1 {name=p991 lab=IN41
m=1}
C {ipin.sym} 5900 -8830 0 1 {name=p992 lab=IN42}
C {ipin.sym} 5900 -8690 0 1 {name=p993 lab=IN43
m=1}
C {ipin.sym} 5890 -8550 0 1 {name=p994 lab=IN44
m=1}
C {ipin.sym} 5910 -8410 0 1 {name=p995 lab=IN45
m=1}
C {ipin.sym} 5900 -8270 0 1 {name=p996 lab=IN46
m=1}
C {ipin.sym} 5900 -8130 0 1 {name=p997 lab=IN47
m=1}
C {ipin.sym} 5890 -7990 0 1 {name=p998 lab=IN48
m=1}
C {ipin.sym} 5900 -7850 0 1 {name=p999 lab=IN49
m=1}
C {ipin.sym} 5890 -7710 0 1 {name=p1000 lab=IN50
m=1}
C {ipin.sym} 5900 -7570 0 1 {name=p1001 lab=IN51
m=1}
C {ipin.sym} 5890 -7430 0 1 {name=p1002 lab=IN52
m=1}
C {ipin.sym} 5890 -7290 0 1 {name=p1003 lab=IN53
m=1}
C {ipin.sym} 5880 -7150 0 1 {name=p1004 lab=IN54
m=1}
C {ipin.sym} 5890 -7010 0 1 {name=p1005 lab=IN55
m=1}
C {ipin.sym} 5880 -6870 0 1 {name=p1006 lab=IN56
m=1}
C {ipin.sym} 5880 -6730 0 1 {name=p1007 lab=IN57
m=1}
C {ipin.sym} 5870 -6590 0 1 {name=p1008 lab=IN58
m=1}
C {ipin.sym} 5890 -6450 0 1 {name=p1009 lab=IN59
m=1}
C {ipin.sym} 5880 -6310 0 1 {name=p1010 lab=IN60
m=1}
C {ipin.sym} 5880 -6170 0 1 {name=p1011 lab=IN61
m=1}
C {ipin.sym} 5870 -6030 0 1 {name=p1012 lab=IN62
m=1}
C {lab_wire.sym} 3670 -4890 0 0 {name=p1020 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3670 -4650 0 0 {name=p1021 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3540 -4760 0 0 {name=p1022 sig_type=std_logic lab=B4bar_mux}
C {symbols/pfet_03v3.sym} 3650 -4840 0 0 {name=M423
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 3650 -4690 0 0 {name=M424
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 3675 -4840 0 0 {name=p1023 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3685 -4690 0 0 {name=p1024 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3980 -4890 0 0 {name=p1025 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3980 -4650 0 0 {name=p1026 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3850 -4760 0 0 {name=p1027 sig_type=std_logic lab=B3bar_mux}
C {symbols/pfet_03v3.sym} 3960 -4840 0 0 {name=M425
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 3960 -4690 0 0 {name=M426
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 3985 -4840 0 0 {name=p1028 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3995 -4690 0 0 {name=p1029 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4300 -4890 0 0 {name=p1030 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4300 -4650 0 0 {name=p1031 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4170 -4760 0 0 {name=p1032 sig_type=std_logic lab=B2bar_mux}
C {symbols/pfet_03v3.sym} 4280 -4840 0 0 {name=M427
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4280 -4690 0 0 {name=M428
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4305 -4840 0 0 {name=p1033 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4315 -4690 0 0 {name=p1034 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4620 -4890 0 0 {name=p1035 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4620 -4650 0 0 {name=p1036 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4490 -4760 0 0 {name=p1037 sig_type=std_logic lab=B1bar_mux}
C {symbols/pfet_03v3.sym} 4600 -4840 0 0 {name=M429
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4600 -4690 0 0 {name=M430
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4625 -4840 0 0 {name=p1038 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4635 -4690 0 0 {name=p1039 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4940 -4890 0 0 {name=p1040 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4940 -4650 0 0 {name=p1041 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4810 -4760 0 0 {name=p1042 sig_type=std_logic lab=B0bar_mux}
C {symbols/pfet_03v3.sym} 4920 -4840 0 0 {name=M431
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4920 -4690 0 0 {name=M432
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4945 -4840 0 0 {name=p1043 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4955 -4690 0 0 {name=p1044 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3300 -5890 0 0 {name=p1046 sig_type=std_logic lab=B4bar}
C {lab_wire.sym} 3500 -5890 0 0 {name=p1047 sig_type=std_logic lab=B3bar}
C {lab_wire.sym} 3700 -5880 0 0 {name=p1048 sig_type=std_logic lab=B2bar}
C {lab_wire.sym} 3900 -5870 0 0 {name=p1049 sig_type=std_logic lab=B1bar}
C {lab_wire.sym} 4100 -5870 0 0 {name=p1050 sig_type=std_logic lab=B0bar}
C {opin.sym} 3720 -4760 0 0 {name=p945 lab=B4}
C {opin.sym} 4060 -4760 0 0 {name=p946 lab=B3}
C {opin.sym} 4380 -4760 0 0 {name=p947 lab=B2}
C {opin.sym} 4680 -4760 0 0 {name=p948 lab=B1}
C {opin.sym} 4990 -4760 0 0 {name=p949 lab=B0}
C {symbols/ppolyf_u_1k.sym} 3300 -10370 0 0 {name=R1
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {symbols/ppolyf_u_1k.sym} 3500 -10370 0 0 {name=R2
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 3480 -10370 3 0 {name=p5 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 3700 -10370 0 0 {name=R3
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 3680 -10370 3 0 {name=p6 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 3900 -10370 0 0 {name=R4
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 3880 -10370 3 0 {name=p7 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 4100 -10370 0 0 {name=R5
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 4080 -10370 3 0 {name=p8 sig_type=std_logic lab=GND}
C {lab_wire.sym} 4460 -10340 0 1 {name=p9 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 4660 -10340 0 1 {name=p11 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 4860 -10340 0 1 {name=p13 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 5060 -10340 0 1 {name=p15 sig_type=std_logic lab=VDD
m=55}
C {lab_wire.sym} 5260 -10340 0 1 {name=p17 sig_type=std_logic lab=VDD
m=55}
C {symbols/ppolyf_u_1k.sym} 5200 -10370 0 1 {name=R7
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 5220 -10370 1 1 {name=p28 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 5000 -10370 0 1 {name=R8
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 5020 -10370 1 1 {name=p29 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 4800 -10370 0 1 {name=R9
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 4820 -10370 1 1 {name=p30 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 4600 -10370 0 1 {name=R10
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 4620 -10370 1 1 {name=p31 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_1k.sym} 4400 -10370 0 1 {name=R11
W=1e-6
L=2e-5
model=ppolyf_u_1k
spiceprefix=X
m=1
spice_ignore=false}
C {lab_pin.sym} 4420 -10370 1 1 {name=p32 sig_type=std_logic lab=GND}
C {lab_wire.sym} 5200 -5890 0 1 {name=p1 sig_type=std_logic lab=B4bar_h
}
C {lab_wire.sym} 5000 -5890 0 1 {name=p3 sig_type=std_logic lab=B3bar_h}
C {lab_wire.sym} 4800 -5880 0 1 {name=p19 sig_type=std_logic lab=B2bar_h}
C {lab_wire.sym} 4600 -5870 0 1 {name=p25 sig_type=std_logic lab=B1bar_h}
C {lab_wire.sym} 4400 -5870 0 1 {name=p26 sig_type=std_logic lab=B0bar_h}
C {symbols/pfet_03v3.sym} 3730 -5720 3 1 {name=M6
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 3730 -5520 1 1 {name=M7
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 3730 -5540 1 0 {name=p2 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 3730 -5700 3 0 {name=p27 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 4150 -5720 3 1 {name=M8
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4150 -5520 1 1 {name=M9
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4150 -5540 1 0 {name=p33 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 4150 -5700 3 0 {name=p34 sig_type=std_logic lab=VDD}
C {ipin.sym} 3000 -5600 0 0 {name=p35 lab=THERMOMETER_31}
C {lab_wire.sym} 3730 -5500 2 1 {name=p37 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 4150 -5500 2 1 {name=p38 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 3580 -5620 0 0 {name=p41 sig_type=std_logic lab=B4bar_h}
C {lab_wire.sym} 4000 -5620 0 0 {name=p42 sig_type=std_logic lab=B3bar_h}
C {symbols/pfet_03v3.sym} 4530 -5720 3 1 {name=M10
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4530 -5520 1 1 {name=M11
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4530 -5540 1 0 {name=p43 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 4530 -5700 3 0 {name=p44 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4530 -5500 2 1 {name=p45 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 4380 -5620 0 0 {name=p47 sig_type=std_logic lab=B2bar_h}
C {symbols/pfet_03v3.sym} 4910 -5720 3 1 {name=M12
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4910 -5520 1 1 {name=M13
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4910 -5540 1 0 {name=p48 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 4910 -5700 3 0 {name=p49 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4910 -5500 2 1 {name=p50 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 4760 -5620 0 0 {name=p52 sig_type=std_logic lab=B1bar_h}
C {symbols/pfet_03v3.sym} 5250 -5720 3 1 {name=M14
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 5250 -5520 1 1 {name=M15
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 5250 -5540 1 0 {name=p53 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 5250 -5700 3 0 {name=p54 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5250 -5500 2 1 {name=p55 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 5100 -5620 0 0 {name=p57 sig_type=std_logic lab=B0bar_h}
C {symbols/pfet_03v3.sym} 3730 -5380 3 1 {name=M16
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 3730 -5180 1 1 {name=M17
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 3730 -5200 1 0 {name=p58 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 3730 -5360 3 0 {name=p59 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 4150 -5380 3 1 {name=M18
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4150 -5180 1 1 {name=M19
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4150 -5200 1 0 {name=p60 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 4150 -5360 3 0 {name=p61 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3730 -5400 0 0 {name=p62 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 4150 -5400 0 0 {name=p63 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 3730 -5160 2 1 {name=p64 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 4150 -5160 2 1 {name=p65 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 3580 -5280 0 0 {name=p66 sig_type=std_logic lab=B4bar}
C {lab_wire.sym} 4000 -5280 0 0 {name=p67 sig_type=std_logic lab=B3bar}
C {symbols/pfet_03v3.sym} 4530 -5380 3 1 {name=M20
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4530 -5180 1 1 {name=M21
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4530 -5200 1 0 {name=p68 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 4530 -5360 3 0 {name=p69 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4530 -5400 0 0 {name=p70 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 4530 -5160 2 1 {name=p71 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 4380 -5280 0 0 {name=p72 sig_type=std_logic lab=B2bar}
C {symbols/pfet_03v3.sym} 4910 -5380 3 1 {name=M22
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 4910 -5180 1 1 {name=M23
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 4910 -5200 1 0 {name=p73 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 4910 -5360 3 0 {name=p74 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4910 -5400 0 0 {name=p75 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 4910 -5160 2 1 {name=p76 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 4760 -5280 0 0 {name=p77 sig_type=std_logic lab=B1bar}
C {symbols/pfet_03v3.sym} 5250 -5380 3 1 {name=M24
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 5250 -5180 1 1 {name=M25
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 5250 -5200 1 0 {name=p78 sig_type=std_logic lab=GND
m=-4}
C {lab_wire.sym} 5250 -5360 3 0 {name=p79 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5250 -5400 0 0 {name=p80 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 5250 -5160 2 1 {name=p81 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 5100 -5280 0 0 {name=p82 sig_type=std_logic lab=B0bar}
C {lab_wire.sym} 3820 -5620 0 1 {name=p83 sig_type=std_logic lab=B4bar_mux}
C {lab_wire.sym} 4190 -5620 0 1 {name=p84 sig_type=std_logic lab=B3bar_mux}
C {lab_wire.sym} 4570 -5620 0 1 {name=p85 sig_type=std_logic lab=B2bar_mux}
C {lab_wire.sym} 4950 -5620 0 1 {name=p86 sig_type=std_logic lab=B1bar_mux}
C {lab_wire.sym} 5340 -5620 0 1 {name=p87 sig_type=std_logic lab=B0bar_mux}
C {lab_wire.sym} 3820 -5280 0 1 {name=p88 sig_type=std_logic lab=B4bar_mux}
C {lab_wire.sym} 4190 -5280 0 1 {name=p89 sig_type=std_logic lab=B3bar_mux}
C {lab_wire.sym} 4570 -5280 0 1 {name=p90 sig_type=std_logic lab=B2bar_mux}
C {lab_wire.sym} 4950 -5280 0 1 {name=p91 sig_type=std_logic lab=B1bar_mux}
C {lab_wire.sym} 5340 -5280 0 1 {name=p92 sig_type=std_logic lab=B0bar_mux}
C {lab_wire.sym} 3020 -5340 0 0 {name=p93 sig_type=std_logic lab=THERMOMETER_31}
C {lab_wire.sym} 3270 -5470 0 0 {name=p94 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3270 -5230 0 0 {name=p95 sig_type=std_logic lab=GND}
C {symbols/pfet_03v3.sym} 3250 -5420 0 0 {name=M26
L=0.28u
W=1.32u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
lab=invp}
C {symbols/nfet_03v3.sym} 3250 -5270 0 0 {name=M27
L=0.28u
W=0.44u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
lab=invn}
C {lab_wire.sym} 3275 -5420 0 0 {name=p97 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3285 -5270 0 0 {name=p98 sig_type=std_logic lab=GND}
C {lab_wire.sym} 3300 -5340 0 1 {name=p96 sig_type=std_logic lab=THERMOMETER_31bar}
C {opin.sym} 3160 -5600 0 0 {name=p36 lab=B5}
C {ammeter.sym} 3090 -5600 3 0 {name=Vmeas savecurrent=false spice_ignore=0 lvs_ignore=true}
C {ipin.sym} 3240 -10360 0 0 {name=p99 lab=VDD}
C {ipin.sym} 3280 -10370 0 0 {name=p4 lab=GND}
C {lab_wire.sym} 3730 -5740 0 0 {name=p10 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 4150 -5740 0 0 {name=p12 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 4530 -5740 0 0 {name=p14 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 4910 -5740 0 0 {name=p16 sig_type=std_logic lab=THERMOMETER_31bar}
C {lab_wire.sym} 5250 -5740 0 0 {name=p18 sig_type=std_logic lab=THERMOMETER_31bar}
