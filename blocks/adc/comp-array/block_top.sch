v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 50 600 100 600 {lab=vrefp}
N 100 440 100 600 {lab=vrefp}
N 100 440 140 440 {lab=vrefp}
N 120 460 140 460 {lab=vrefn}
N 120 460 120 620 {lab=vrefn}
N 50 620 120 620 {lab=vrefn}
N 860 720 930 720 {lab=#net1}
N 930 720 930 800 {lab=#net1}
N 930 800 1330 800 {lab=#net1}
N 860 740 910 740 {lab=#net2}
N 910 740 910 820 {lab=#net2}
N 910 820 1330 820 {lab=#net2}
N 860 460 900 460 {lab=#net3}
N 860 480 920 480 {lab=#net4}
N 860 870 900 870 {lab=#net5}
N 900 870 900 980 {lab=#net5}
N 860 850 920 850 {lab=#net6}
N 920 850 920 1000 {lab=#net6}
N 920 1000 1330 1000 {lab=#net6}
N 900 980 900 1020 {lab=#net5}
N 900 1020 1330 1020 {lab=#net5}
N 900 450 970 450 {lab=#net3}
N 920 470 970 470 {lab=#net4}
N 930 510 970 510 {lab=#net7}
N 930 510 930 610 {lab=#net7}
N 910 490 970 490 {lab=#net8}
N 910 490 910 590 {lab=#net8}
N 930 610 930 670 {lab=#net7}
N 930 670 970 670 {lab=#net7}
N 950 650 970 650 {lab=#net8}
N 950 590 950 650 {lab=#net8}
N 910 710 970 710 {lab=#net2}
N 910 710 910 740 {lab=#net2}
N 890 690 970 690 {lab=#net1}
N 890 690 890 720 {lab=#net1}
N 960 850 970 850 {lab=#net1}
N 960 800 960 850 {lab=#net1}
N 940 870 970 870 {lab=#net2}
N 940 820 940 870 {lab=#net2}
N 920 890 970 890 {lab=#net6}
N 900 910 970 910 {lab=#net5}
N 2060 620 2120 620 {lab=q[62]}
N 2060 710 2120 710 {lab=q[61]}
N 2060 800 2120 800 {lab=q[60]}
N 2320 890 2380 890 {lab=q[59]}
N 2060 980 2120 980 {lab=q[58]}
N 2060 1070 2120 1070 {lab=q[57]}
N 2060 1160 2120 1160 {lab=q[56]}
N 2320 1250 2380 1250 {lab=q[55]}
N 1270 660 1530 660 {lab=#net9}
N 1530 600 1530 660 {lab=#net9}
N 1530 600 1760 600 {lab=#net9}
N 1550 620 1760 620 {lab=#net10}
N 1550 620 1550 680 {lab=#net10}
N 1270 680 1550 680 {lab=#net10}
N 1270 700 1570 700 {lab=#net11}
N 1570 690 1570 700 {lab=#net11}
N 1570 690 1760 690 {lab=#net11}
N 1590 710 1760 710 {lab=#net12}
N 1270 720 1590 720 {lab=#net12}
N 1590 710 1590 720 {lab=#net12}
N 1330 1020 1330 1250 {lab=#net5}
N 1330 1000 1350 1000 {lab=#net6}
N 1350 1000 1350 1230 {lab=#net6}
N 1270 960 1370 960 {lab=#net13}
N 1370 960 1370 1160 {lab=#net13}
N 1370 1160 1760 1160 {lab=#net13}
N 1390 1140 1760 1140 {lab=#net14}
N 1390 940 1390 1140 {lab=#net14}
N 1270 940 1390 940 {lab=#net14}
N 1270 920 1410 920 {lab=#net15}
N 1410 920 1410 1070 {lab=#net15}
N 1410 1070 1760 1070 {lab=#net15}
N 1430 1050 1760 1050 {lab=#net16}
N 1430 910 1430 1050 {lab=#net16}
N 1270 900 1430 900 {lab=#net16}
N 1430 900 1430 910 {lab=#net16}
N 1270 880 1450 880 {lab=#net17}
N 1450 880 1450 980 {lab=#net17}
N 1450 980 1760 980 {lab=#net17}
N 1470 960 1760 960 {lab=#net18}
N 1470 870 1470 960 {lab=#net18}
N 1470 860 1470 870 {lab=#net18}
N 1270 860 1470 860 {lab=#net18}
N 1330 820 1490 820 {lab=#net2}
N 1490 820 1490 890 {lab=#net2}
N 1330 800 1510 800 {lab=#net1}
N 1510 800 1510 870 {lab=#net1}
N 1270 760 1530 760 {lab=#net19}
N 1530 760 1530 800 {lab=#net19}
N 1530 800 1760 800 {lab=#net19}
N 1270 740 1550 740 {lab=#net20}
N 1550 740 1550 780 {lab=#net20}
N 1550 780 1760 780 {lab=#net20}
N 2060 1340 2120 1340 {lab=q[54]}
N 2060 1430 2120 1430 {lab=q[53]}
N 2060 1520 2120 1520 {lab=q[52]}
N 1270 1390 1330 1390 {lab=#net21}
N 1330 1320 1330 1390 {lab=#net21}
N 1270 1410 1350 1410 {lab=#net22}
N 1350 1340 1350 1410 {lab=#net22}
N 1270 1430 1370 1430 {lab=#net23}
N 1370 1410 1370 1430 {lab=#net23}
N 1270 1450 1390 1450 {lab=#net24}
N 1390 1430 1390 1450 {lab=#net24}
N 1270 1470 1390 1470 {lab=#net25}
N 1390 1470 1390 1500 {lab=#net25}
N 1270 1490 1370 1490 {lab=#net26}
N 1370 1490 1370 1510 {lab=#net26}
N 1370 1510 1370 1520 {lab=#net26}
N 900 450 900 460 {lab=#net3}
N 920 470 920 480 {lab=#net4}
N 1350 1340 1760 1340 {lab=#net22}
N 1330 1320 1760 1320 {lab=#net21}
N 1370 1410 1760 1410 {lab=#net23}
N 1390 1430 1760 1430 {lab=#net24}
N 1390 1500 1760 1500 {lab=#net25}
N 1370 1520 1760 1520 {lab=#net26}
N 2320 1610 2380 1610 {lab=q[51]}
N 2060 1700 2120 1700 {lab=q[50]}
N 2060 1790 2120 1790 {lab=q[49]}
N 2060 1880 2120 1880 {lab=q[48]}
N 2320 1970 2380 1970 {lab=q[47]}
N 2060 2060 2120 2060 {lab=q[46]}
N 2060 2150 2120 2150 {lab=q[45]}
N 2060 2240 2120 2240 {lab=q[44]}
N 2320 2330 2380 2330 {lab=q[43]}
N 2060 2420 2120 2420 {lab=q[42]}
N 2060 2510 2120 2510 {lab=q[41]}
N 2060 2600 2120 2600 {lab=q[40]}
N 2320 2690 2380 2690 {lab=q[39]}
N 2060 2780 2120 2780 {lab=q[38]}
N 2060 2870 2120 2870 {lab=q[37]}
N 2060 2960 2120 2960 {lab=q[36]}
N 2320 3050 2380 3050 {lab=q[35]}
N 2060 3140 2120 3140 {lab=q[34]}
N 2060 3230 2120 3230 {lab=q[33]}
N 2060 3320 2120 3320 {lab=q[32]}
N 2320 3410 2380 3410 {lab=q[31]}
N 2060 3500 2120 3500 {lab=q[30]}
N 2060 3590 2120 3590 {lab=q[29]}
N 2060 3680 2120 3680 {lab=q[28]}
N 2320 3770 2380 3770 {lab=q[27]}
N 2060 3860 2120 3860 {lab=q[26]}
N 2060 3950 2120 3950 {lab=q[25]}
N 2060 4040 2120 4040 {lab=q[24]}
N 2320 4130 2380 4130 {lab=q[23]}
N 2060 4220 2120 4220 {lab=q[22]}
N 2060 4310 2120 4310 {lab=q[21]}
N 2060 4400 2120 4400 {lab=q[20]}
N 2320 4490 2380 4490 {lab=q[19]}
N 2060 4580 2120 4580 {lab=q[18]}
N 2060 4670 2120 4670 {lab=q[17]}
N 2060 4760 2120 4760 {lab=q[16]}
N 2320 4850 2380 4850 {lab=q[15]}
N 2060 4940 2120 4940 {lab=q[14]}
N 2060 5030 2120 5030 {lab=q[13]}
N 2060 5120 2120 5120 {lab=q[12]}
N 2320 5210 2380 5210 {lab=q[11]}
N 2060 5300 2120 5300 {lab=q[10]}
N 2060 5390 2120 5390 {lab=q[9]}
N 2060 5480 2120 5480 {lab=q[8]}
N 2320 5570 2380 5570 {lab=q[7]}
N 2060 5660 2120 5660 {lab=q[6]}
N 2060 5750 2120 5750 {lab=q[5]}
N 2060 5840 2120 5840 {lab=q[4]}
N 2320 5930 2380 5930 {lab=q[3]}
N 2060 6020 2120 6020 {lab=q[2]}
N 2060 6110 2120 6110 {lab=q[1]}
N 860 1610 900 1610 {lab=#net27}
N 860 1590 900 1590 {lab=#net28}
N 900 1420 900 1590 {lab=#net28}
N 900 1420 970 1420 {lab=#net28}
N 900 1610 920 1610 {lab=#net27}
N 920 1440 920 1610 {lab=#net27}
N 920 1440 970 1440 {lab=#net27}
N 920 1000 920 1380 {lab=#net6}
N 920 1380 970 1380 {lab=#net6}
N 900 1020 900 1400 {lab=#net5}
N 900 1400 970 1400 {lab=#net5}
N 1270 1750 1330 1750 {lab=#net29}
N 1330 1680 1330 1750 {lab=#net29}
N 1270 1770 1350 1770 {lab=#net30}
N 1350 1700 1350 1770 {lab=#net30}
N 1270 1790 1370 1790 {lab=#net31}
N 1370 1770 1370 1790 {lab=#net31}
N 1270 1810 1390 1810 {lab=#net32}
N 1390 1790 1390 1810 {lab=#net32}
N 1270 1830 1390 1830 {lab=#net33}
N 1390 1830 1390 1860 {lab=#net33}
N 1270 1850 1370 1850 {lab=#net34}
N 1370 1850 1370 1870 {lab=#net34}
N 1370 1870 1370 1880 {lab=#net34}
N 1350 1700 1760 1700 {lab=#net30}
N 1330 1680 1760 1680 {lab=#net29}
N 1370 1770 1760 1770 {lab=#net31}
N 1390 1790 1760 1790 {lab=#net32}
N 1390 1860 1760 1860 {lab=#net33}
N 1370 1880 1760 1880 {lab=#net34}
N 860 1970 900 1970 {lab=#net35}
N 860 1950 900 1950 {lab=#net36}
N 900 1780 900 1950 {lab=#net36}
N 900 1780 970 1780 {lab=#net36}
N 900 1970 920 1970 {lab=#net35}
N 920 1800 920 1970 {lab=#net35}
N 920 1800 970 1800 {lab=#net35}
N 920 1740 970 1740 {lab=#net28}
N 900 1760 970 1760 {lab=#net27}
N 900 1610 900 1760 {lab=#net27}
N 920 1630 920 1740 {lab=#net28}
N 920 1630 940 1630 {lab=#net28}
N 940 1590 940 1630 {lab=#net28}
N 1270 2110 1330 2110 {lab=#net37}
N 1330 2040 1330 2110 {lab=#net37}
N 1270 2130 1350 2130 {lab=#net38}
N 1350 2060 1350 2130 {lab=#net38}
N 1270 2150 1370 2150 {lab=#net39}
N 1370 2130 1370 2150 {lab=#net39}
N 1270 2170 1390 2170 {lab=#net40}
N 1390 2150 1390 2170 {lab=#net40}
N 1270 2190 1390 2190 {lab=#net41}
N 1390 2190 1390 2220 {lab=#net41}
N 1270 2210 1370 2210 {lab=#net42}
N 1370 2210 1370 2230 {lab=#net42}
N 1370 2230 1370 2240 {lab=#net42}
N 1350 2060 1760 2060 {lab=#net38}
N 1330 2040 1760 2040 {lab=#net37}
N 1370 2130 1760 2130 {lab=#net39}
N 1390 2150 1760 2150 {lab=#net40}
N 1390 2220 1760 2220 {lab=#net41}
N 1370 2240 1760 2240 {lab=#net42}
N 860 2330 900 2330 {lab=#net43}
N 860 2310 900 2310 {lab=#net44}
N 900 2140 900 2310 {lab=#net44}
N 900 2140 970 2140 {lab=#net44}
N 900 2330 920 2330 {lab=#net43}
N 920 2160 920 2330 {lab=#net43}
N 920 2160 970 2160 {lab=#net43}
N 920 2100 970 2100 {lab=#net36}
N 900 2120 970 2120 {lab=#net35}
N 900 1970 900 2120 {lab=#net35}
N 920 1990 920 2100 {lab=#net36}
N 920 1990 940 1990 {lab=#net36}
N 940 1950 940 1990 {lab=#net36}
N 1270 2470 1330 2470 {lab=#net45}
N 1330 2400 1330 2470 {lab=#net45}
N 1270 2490 1350 2490 {lab=#net46}
N 1350 2420 1350 2490 {lab=#net46}
N 1270 2510 1370 2510 {lab=#net47}
N 1370 2490 1370 2510 {lab=#net47}
N 1270 2530 1390 2530 {lab=#net48}
N 1390 2510 1390 2530 {lab=#net48}
N 1270 2550 1390 2550 {lab=#net49}
N 1390 2550 1390 2580 {lab=#net49}
N 1270 2570 1370 2570 {lab=#net50}
N 1370 2570 1370 2590 {lab=#net50}
N 1370 2590 1370 2600 {lab=#net50}
N 1350 2420 1760 2420 {lab=#net46}
N 1330 2400 1760 2400 {lab=#net45}
N 1370 2490 1760 2490 {lab=#net47}
N 1390 2510 1760 2510 {lab=#net48}
N 1390 2580 1760 2580 {lab=#net49}
N 1370 2600 1760 2600 {lab=#net50}
N 860 2690 900 2690 {lab=#net51}
N 860 2670 900 2670 {lab=#net52}
N 900 2500 900 2670 {lab=#net52}
N 900 2500 970 2500 {lab=#net52}
N 900 2690 920 2690 {lab=#net51}
N 920 2520 920 2690 {lab=#net51}
N 920 2520 970 2520 {lab=#net51}
N 920 2460 970 2460 {lab=#net44}
N 900 2480 970 2480 {lab=#net43}
N 900 2330 900 2480 {lab=#net43}
N 920 2350 920 2460 {lab=#net44}
N 920 2350 940 2350 {lab=#net44}
N 940 2310 940 2350 {lab=#net44}
N 1270 2830 1330 2830 {lab=#net53}
N 1330 2760 1330 2830 {lab=#net53}
N 1270 2850 1350 2850 {lab=#net54}
N 1350 2780 1350 2850 {lab=#net54}
N 1270 2870 1370 2870 {lab=#net55}
N 1370 2850 1370 2870 {lab=#net55}
N 1270 2890 1390 2890 {lab=#net56}
N 1390 2870 1390 2890 {lab=#net56}
N 1270 2910 1390 2910 {lab=#net57}
N 1390 2910 1390 2940 {lab=#net57}
N 1270 2930 1370 2930 {lab=#net58}
N 1370 2930 1370 2950 {lab=#net58}
N 1370 2950 1370 2960 {lab=#net58}
N 1350 2780 1760 2780 {lab=#net54}
N 1330 2760 1760 2760 {lab=#net53}
N 1370 2850 1760 2850 {lab=#net55}
N 1390 2870 1760 2870 {lab=#net56}
N 1390 2940 1760 2940 {lab=#net57}
N 1370 2960 1760 2960 {lab=#net58}
N 860 3050 900 3050 {lab=#net59}
N 860 3030 900 3030 {lab=#net60}
N 900 2860 900 3030 {lab=#net60}
N 900 2860 970 2860 {lab=#net60}
N 900 3050 920 3050 {lab=#net59}
N 920 2880 920 3050 {lab=#net59}
N 920 2880 970 2880 {lab=#net59}
N 920 2820 970 2820 {lab=#net52}
N 900 2840 970 2840 {lab=#net51}
N 900 2690 900 2840 {lab=#net51}
N 920 2710 920 2820 {lab=#net52}
N 920 2710 940 2710 {lab=#net52}
N 940 2670 940 2710 {lab=#net52}
N 1270 3190 1330 3190 {lab=#net61}
N 1330 3120 1330 3190 {lab=#net61}
N 1270 3210 1350 3210 {lab=#net62}
N 1350 3140 1350 3210 {lab=#net62}
N 1270 3230 1370 3230 {lab=#net63}
N 1370 3210 1370 3230 {lab=#net63}
N 1270 3250 1390 3250 {lab=#net64}
N 1390 3230 1390 3250 {lab=#net64}
N 1270 3270 1390 3270 {lab=#net65}
N 1390 3270 1390 3300 {lab=#net65}
N 1270 3290 1370 3290 {lab=#net66}
N 1370 3290 1370 3310 {lab=#net66}
N 1370 3310 1370 3320 {lab=#net66}
N 1350 3140 1760 3140 {lab=#net62}
N 1330 3120 1760 3120 {lab=#net61}
N 1370 3210 1760 3210 {lab=#net63}
N 1390 3230 1760 3230 {lab=#net64}
N 1390 3300 1760 3300 {lab=#net65}
N 1370 3320 1760 3320 {lab=#net66}
N 860 3410 900 3410 {lab=#net67}
N 860 3390 900 3390 {lab=#net68}
N 900 3220 900 3390 {lab=#net68}
N 900 3220 970 3220 {lab=#net68}
N 900 3410 920 3410 {lab=#net67}
N 920 3240 920 3410 {lab=#net67}
N 920 3240 970 3240 {lab=#net67}
N 920 3180 970 3180 {lab=#net60}
N 900 3200 970 3200 {lab=#net59}
N 900 3050 900 3200 {lab=#net59}
N 920 3070 920 3180 {lab=#net60}
N 920 3070 940 3070 {lab=#net60}
N 940 3030 940 3070 {lab=#net60}
N 1270 3550 1330 3550 {lab=#net69}
N 1330 3480 1330 3550 {lab=#net69}
N 1270 3570 1350 3570 {lab=#net70}
N 1350 3500 1350 3570 {lab=#net70}
N 1270 3590 1370 3590 {lab=#net71}
N 1370 3570 1370 3590 {lab=#net71}
N 1270 3610 1390 3610 {lab=#net72}
N 1390 3590 1390 3610 {lab=#net72}
N 1270 3630 1390 3630 {lab=#net73}
N 1390 3630 1390 3660 {lab=#net73}
N 1270 3650 1370 3650 {lab=#net74}
N 1370 3650 1370 3670 {lab=#net74}
N 1370 3670 1370 3680 {lab=#net74}
N 1350 3500 1760 3500 {lab=#net70}
N 1330 3480 1760 3480 {lab=#net69}
N 1370 3570 1760 3570 {lab=#net71}
N 1390 3590 1760 3590 {lab=#net72}
N 1390 3660 1760 3660 {lab=#net73}
N 1370 3680 1760 3680 {lab=#net74}
N 860 3770 900 3770 {lab=#net75}
N 860 3750 900 3750 {lab=#net76}
N 900 3580 900 3750 {lab=#net76}
N 900 3580 970 3580 {lab=#net76}
N 900 3770 920 3770 {lab=#net75}
N 920 3600 920 3770 {lab=#net75}
N 920 3600 970 3600 {lab=#net75}
N 920 3540 970 3540 {lab=#net68}
N 900 3560 970 3560 {lab=#net67}
N 900 3410 900 3560 {lab=#net67}
N 920 3430 920 3540 {lab=#net68}
N 920 3430 940 3430 {lab=#net68}
N 940 3390 940 3430 {lab=#net68}
N 1270 3910 1330 3910 {lab=#net77}
N 1330 3840 1330 3910 {lab=#net77}
N 1270 3930 1350 3930 {lab=#net78}
N 1350 3860 1350 3930 {lab=#net78}
N 1270 3950 1370 3950 {lab=#net79}
N 1370 3930 1370 3950 {lab=#net79}
N 1270 3970 1390 3970 {lab=#net80}
N 1390 3950 1390 3970 {lab=#net80}
N 1270 3990 1390 3990 {lab=#net81}
N 1390 3990 1390 4020 {lab=#net81}
N 1270 4010 1370 4010 {lab=#net82}
N 1370 4010 1370 4030 {lab=#net82}
N 1370 4030 1370 4040 {lab=#net82}
N 1350 3860 1760 3860 {lab=#net78}
N 1330 3840 1760 3840 {lab=#net77}
N 1370 3930 1760 3930 {lab=#net79}
N 1390 3950 1760 3950 {lab=#net80}
N 1390 4020 1760 4020 {lab=#net81}
N 1370 4040 1760 4040 {lab=#net82}
N 860 4130 900 4130 {lab=#net83}
N 860 4110 900 4110 {lab=#net84}
N 900 3940 900 4110 {lab=#net84}
N 900 3940 970 3940 {lab=#net84}
N 900 4130 920 4130 {lab=#net83}
N 920 3960 920 4130 {lab=#net83}
N 920 3960 970 3960 {lab=#net83}
N 920 3900 970 3900 {lab=#net76}
N 900 3920 970 3920 {lab=#net75}
N 900 3770 900 3920 {lab=#net75}
N 920 3790 920 3900 {lab=#net76}
N 920 3790 940 3790 {lab=#net76}
N 940 3750 940 3790 {lab=#net76}
N 1270 4270 1330 4270 {lab=#net85}
N 1330 4200 1330 4270 {lab=#net85}
N 1270 4290 1350 4290 {lab=#net86}
N 1350 4220 1350 4290 {lab=#net86}
N 1270 4310 1370 4310 {lab=#net87}
N 1370 4290 1370 4310 {lab=#net87}
N 1270 4330 1390 4330 {lab=#net88}
N 1390 4310 1390 4330 {lab=#net88}
N 1270 4350 1390 4350 {lab=#net89}
N 1390 4350 1390 4380 {lab=#net89}
N 1270 4370 1370 4370 {lab=#net90}
N 1370 4370 1370 4390 {lab=#net90}
N 1370 4390 1370 4400 {lab=#net90}
N 1350 4220 1760 4220 {lab=#net86}
N 1330 4200 1760 4200 {lab=#net85}
N 1370 4290 1760 4290 {lab=#net87}
N 1390 4310 1760 4310 {lab=#net88}
N 1390 4380 1760 4380 {lab=#net89}
N 1370 4400 1760 4400 {lab=#net90}
N 860 4490 900 4490 {lab=#net91}
N 860 4470 900 4470 {lab=#net92}
N 900 4300 900 4470 {lab=#net92}
N 900 4300 970 4300 {lab=#net92}
N 900 4490 920 4490 {lab=#net91}
N 920 4320 920 4490 {lab=#net91}
N 920 4320 970 4320 {lab=#net91}
N 920 4260 970 4260 {lab=#net84}
N 900 4280 970 4280 {lab=#net83}
N 900 4130 900 4280 {lab=#net83}
N 920 4150 920 4260 {lab=#net84}
N 920 4150 940 4150 {lab=#net84}
N 940 4110 940 4150 {lab=#net84}
N 1270 4630 1330 4630 {lab=#net93}
N 1330 4560 1330 4630 {lab=#net93}
N 1270 4650 1350 4650 {lab=#net94}
N 1350 4580 1350 4650 {lab=#net94}
N 1270 4670 1370 4670 {lab=#net95}
N 1370 4650 1370 4670 {lab=#net95}
N 1270 4690 1390 4690 {lab=#net96}
N 1390 4670 1390 4690 {lab=#net96}
N 1270 4710 1390 4710 {lab=#net97}
N 1390 4710 1390 4740 {lab=#net97}
N 1270 4730 1370 4730 {lab=#net98}
N 1370 4730 1370 4750 {lab=#net98}
N 1370 4750 1370 4760 {lab=#net98}
N 1350 4580 1760 4580 {lab=#net94}
N 1330 4560 1760 4560 {lab=#net93}
N 1370 4650 1760 4650 {lab=#net95}
N 1390 4670 1760 4670 {lab=#net96}
N 1390 4740 1760 4740 {lab=#net97}
N 1370 4760 1760 4760 {lab=#net98}
N 860 4850 900 4850 {lab=#net99}
N 860 4830 900 4830 {lab=#net100}
N 900 4660 900 4830 {lab=#net100}
N 900 4660 970 4660 {lab=#net100}
N 900 4850 920 4850 {lab=#net99}
N 920 4680 920 4850 {lab=#net99}
N 920 4680 970 4680 {lab=#net99}
N 920 4620 970 4620 {lab=#net92}
N 900 4640 970 4640 {lab=#net91}
N 900 4490 900 4640 {lab=#net91}
N 920 4510 920 4620 {lab=#net92}
N 920 4510 940 4510 {lab=#net92}
N 940 4470 940 4510 {lab=#net92}
N 1270 4990 1330 4990 {lab=#net101}
N 1330 4920 1330 4990 {lab=#net101}
N 1270 5010 1350 5010 {lab=#net102}
N 1350 4940 1350 5010 {lab=#net102}
N 1270 5030 1370 5030 {lab=#net103}
N 1370 5010 1370 5030 {lab=#net103}
N 1270 5050 1390 5050 {lab=#net104}
N 1390 5030 1390 5050 {lab=#net104}
N 1270 5070 1390 5070 {lab=#net105}
N 1390 5070 1390 5100 {lab=#net105}
N 1270 5090 1370 5090 {lab=#net106}
N 1370 5090 1370 5110 {lab=#net106}
N 1370 5110 1370 5120 {lab=#net106}
N 1350 4940 1760 4940 {lab=#net102}
N 1330 4920 1760 4920 {lab=#net101}
N 1370 5010 1760 5010 {lab=#net103}
N 1390 5030 1760 5030 {lab=#net104}
N 1390 5100 1760 5100 {lab=#net105}
N 1370 5120 1760 5120 {lab=#net106}
N 860 5210 900 5210 {lab=#net107}
N 860 5190 900 5190 {lab=#net108}
N 900 5020 900 5190 {lab=#net108}
N 900 5020 970 5020 {lab=#net108}
N 900 5210 920 5210 {lab=#net107}
N 920 5040 920 5210 {lab=#net107}
N 920 5040 970 5040 {lab=#net107}
N 920 4980 970 4980 {lab=#net100}
N 900 5000 970 5000 {lab=#net99}
N 900 4850 900 5000 {lab=#net99}
N 920 4870 920 4980 {lab=#net100}
N 920 4870 940 4870 {lab=#net100}
N 940 4830 940 4870 {lab=#net100}
N 1270 5350 1330 5350 {lab=#net109}
N 1330 5280 1330 5350 {lab=#net109}
N 1270 5370 1350 5370 {lab=#net110}
N 1350 5300 1350 5370 {lab=#net110}
N 1270 5390 1370 5390 {lab=#net111}
N 1370 5370 1370 5390 {lab=#net111}
N 1270 5410 1390 5410 {lab=#net112}
N 1390 5390 1390 5410 {lab=#net112}
N 1270 5430 1390 5430 {lab=#net113}
N 1390 5430 1390 5460 {lab=#net113}
N 1270 5450 1370 5450 {lab=#net114}
N 1370 5450 1370 5470 {lab=#net114}
N 1370 5470 1370 5480 {lab=#net114}
N 1350 5300 1760 5300 {lab=#net110}
N 1330 5280 1760 5280 {lab=#net109}
N 1370 5370 1760 5370 {lab=#net111}
N 1390 5390 1760 5390 {lab=#net112}
N 1390 5460 1760 5460 {lab=#net113}
N 1370 5480 1760 5480 {lab=#net114}
N 860 5570 900 5570 {lab=#net115}
N 860 5550 900 5550 {lab=#net116}
N 900 5380 900 5550 {lab=#net116}
N 900 5380 970 5380 {lab=#net116}
N 900 5570 920 5570 {lab=#net115}
N 920 5400 920 5570 {lab=#net115}
N 920 5400 970 5400 {lab=#net115}
N 920 5340 970 5340 {lab=#net108}
N 900 5360 970 5360 {lab=#net107}
N 900 5210 900 5360 {lab=#net107}
N 920 5230 920 5340 {lab=#net108}
N 920 5230 940 5230 {lab=#net108}
N 940 5190 940 5230 {lab=#net108}
N 1270 5710 1330 5710 {lab=#net117}
N 1330 5640 1330 5710 {lab=#net117}
N 1270 5730 1350 5730 {lab=#net118}
N 1350 5660 1350 5730 {lab=#net118}
N 1270 5750 1370 5750 {lab=#net119}
N 1370 5730 1370 5750 {lab=#net119}
N 1270 5770 1390 5770 {lab=#net120}
N 1390 5750 1390 5770 {lab=#net120}
N 1270 5790 1390 5790 {lab=#net121}
N 1390 5790 1390 5820 {lab=#net121}
N 1270 5810 1370 5810 {lab=#net122}
N 1370 5810 1370 5830 {lab=#net122}
N 1370 5830 1370 5840 {lab=#net122}
N 1350 5660 1760 5660 {lab=#net118}
N 1330 5640 1760 5640 {lab=#net117}
N 1370 5730 1760 5730 {lab=#net119}
N 1390 5750 1760 5750 {lab=#net120}
N 1390 5820 1760 5820 {lab=#net121}
N 1370 5840 1760 5840 {lab=#net122}
N 860 5930 900 5930 {lab=#net123}
N 860 5910 900 5910 {lab=#net124}
N 900 5740 900 5910 {lab=#net124}
N 900 5740 970 5740 {lab=#net124}
N 900 5930 920 5930 {lab=#net123}
N 920 5760 920 5930 {lab=#net123}
N 920 5760 970 5760 {lab=#net123}
N 920 5700 970 5700 {lab=#net116}
N 900 5720 970 5720 {lab=#net115}
N 900 5570 900 5720 {lab=#net115}
N 920 5590 920 5700 {lab=#net116}
N 920 5590 940 5590 {lab=#net116}
N 940 5550 940 5590 {lab=#net116}
N 1270 6070 1330 6070 {lab=#net125}
N 1330 6000 1330 6070 {lab=#net125}
N 1270 6090 1350 6090 {lab=#net126}
N 1350 6020 1350 6090 {lab=#net126}
N 1270 6110 1370 6110 {lab=#net127}
N 1370 6090 1370 6110 {lab=#net127}
N 1270 6130 1390 6130 {lab=#net128}
N 1390 6110 1390 6130 {lab=#net128}
N 1270 6150 1390 6150 {lab=#net129}
N 1390 6150 1390 6180 {lab=#net129}
N 1270 6170 1370 6170 {lab=#net130}
N 1370 6170 1370 6190 {lab=#net130}
N 1370 6190 1370 6200 {lab=#net130}
N 1350 6020 1760 6020 {lab=#net126}
N 1330 6000 1760 6000 {lab=#net125}
N 1370 6090 1760 6090 {lab=#net127}
N 1390 6110 1760 6110 {lab=#net128}
N 1390 6180 1760 6180 {lab=#net129}
N 1370 6200 1760 6200 {lab=#net130}
N 860 6290 900 6290 {lab=#net131}
N 860 6270 900 6270 {lab=#net132}
N 900 6100 900 6270 {lab=#net132}
N 900 6100 970 6100 {lab=#net132}
N 900 6290 920 6290 {lab=#net131}
N 920 6120 920 6290 {lab=#net131}
N 920 6120 970 6120 {lab=#net131}
N 920 6060 970 6060 {lab=#net124}
N 900 6080 970 6080 {lab=#net123}
N 900 5930 900 6080 {lab=#net123}
N 920 5950 920 6060 {lab=#net124}
N 920 5950 940 5950 {lab=#net124}
N 940 5910 940 5950 {lab=#net124}
N 860 6650 900 6650 {lab=#net133}
N 860 6630 900 6630 {lab=#net134}
N 900 6460 900 6630 {lab=#net134}
N 900 6460 970 6460 {lab=#net134}
N 900 6650 920 6650 {lab=#net133}
N 920 6480 920 6650 {lab=#net133}
N 920 6480 970 6480 {lab=#net133}
N 920 6420 970 6420 {lab=#net132}
N 900 6440 970 6440 {lab=#net131}
N 900 6290 900 6440 {lab=#net131}
N 920 6310 920 6420 {lab=#net132}
N 920 6310 940 6310 {lab=#net132}
N 940 6270 940 6310 {lab=#net132}
N 900 6270 940 6270 {lab=#net132}
N 860 610 930 610 {lab=#net7}
N 860 590 950 590 {lab=#net8}
N 2060 6200 2120 6200 {lab=q[0]}
N 290 960 290 980 {lab=vss}
N 290 880 290 900 {lab=vctr}
N 1870 870 2020 870 {lab=#net135}
N 1870 890 2020 890 {lab=#net136}
N 1350 1230 1440 1230 {lab=#net6}
N 1330 1250 1440 1250 {lab=#net5}
N 900 1590 1500 1590 {lab=#net28}
N 920 1610 1500 1610 {lab=#net27}
N 1800 1590 2020 1590 {lab=#net137}
N 1800 1610 2020 1610 {lab=#net138}
N 1800 1950 2020 1950 {lab=#net139}
N 1800 1970 2020 1970 {lab=#net140}
N 900 1950 1500 1950 {lab=#net36}
N 920 1970 1500 1970 {lab=#net35}
N 1800 2310 2020 2310 {lab=#net141}
N 1800 2330 2020 2330 {lab=#net142}
N 900 2310 1500 2310 {lab=#net44}
N 920 2330 1500 2330 {lab=#net43}
N 1800 2670 2020 2670 {lab=#net143}
N 1800 2690 2020 2690 {lab=#net144}
N 900 2670 1500 2670 {lab=#net52}
N 920 2690 1500 2690 {lab=#net51}
N 900 3030 1500 3030 {lab=#net60}
N 920 3050 1500 3050 {lab=#net59}
N 1800 3030 2020 3030 {lab=#net145}
N 1800 3050 2020 3050 {lab=#net146}
N 1800 3410 2020 3410 {lab=#net147}
N 1800 3390 2020 3390 {lab=#net148}
N 920 3410 1500 3410 {lab=#net67}
N 900 3390 1500 3390 {lab=#net68}
N 1800 3770 2020 3770 {lab=#net149}
N 1800 3750 2020 3750 {lab=#net150}
N 900 3750 1500 3750 {lab=#net76}
N 920 3770 1500 3770 {lab=#net75}
N 1800 4130 2020 4130 {lab=#net151}
N 1800 4110 2020 4110 {lab=#net152}
N 920 4130 1500 4130 {lab=#net83}
N 900 4110 1500 4110 {lab=#net84}
N 1800 4490 2020 4490 {lab=#net153}
N 1800 4470 2020 4470 {lab=#net154}
N 900 4470 1500 4470 {lab=#net92}
N 920 4490 1500 4490 {lab=#net91}
N 1800 4850 2020 4850 {lab=#net155}
N 1800 4830 2020 4830 {lab=#net156}
N 900 4830 1500 4830 {lab=#net100}
N 920 4850 1500 4850 {lab=#net99}
N 1800 5210 2020 5210 {lab=#net157}
N 1800 5190 2020 5190 {lab=#net158}
N 900 5190 1500 5190 {lab=#net108}
N 920 5210 1500 5210 {lab=#net107}
N 1800 5570 2020 5570 {lab=#net159}
N 1800 5550 2020 5550 {lab=#net160}
N 920 5570 1500 5570 {lab=#net115}
N 900 5550 1500 5550 {lab=#net116}
N 1800 5930 2020 5930 {lab=#net161}
N 1800 5910 2020 5910 {lab=#net162}
N 900 5910 1500 5910 {lab=#net124}
N 920 5930 1500 5930 {lab=#net123}
N 1800 1230 2020 1230 {lab=#net163}
N 1800 1250 2020 1250 {lab=#net164}
N 1440 1230 1500 1230 {lab=#net6}
N 1440 1250 1500 1250 {lab=#net5}
N 1510 870 1530 870 {lab=#net1}
N 1490 890 1530 890 {lab=#net2}
N 1830 870 1870 870 {lab=#net135}
N 1830 890 1870 890 {lab=#net136}
C {title.sym} -80 -10 0 0 {name=l2 author="Pranav Vadde"}
C {/headless/eda/designs/gf180_flash_adc/bias.sym} -100 490 0 0 {name=x1}
C {lab_wire.sym} -230 480 0 0 {name=p13 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -230 500 0 0 {name=p1 sig_type=std_logic lab=vss}
C {lab_wire.sym} 20 490 0 1 {name=p2 sig_type=std_logic lab=nbias
}
C {/headless/eda/designs/gf180_flash_adc/cmref.sym} -100 620 0 0 {name=x2}
C {lab_wire.sym} 50 580 0 1 {name=p3 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 50 640 0 1 {name=p6 sig_type=std_logic lab=vctr
}
C {lab_wire.sym} -250 590 0 0 {name=p7 sig_type=std_logic lab=vcm_p}
C {lab_wire.sym} -250 610 0 0 {name=p8 sig_type=std_logic lab=vcm_n}
C {lab_wire.sym} -250 650 0 0 {name=p9 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/ladder.sym} 290 610 0 0 {name=x3}
C {lab_wire.sym} 440 610 0 1 {name=p10 sig_type=std_logic lab=vctr
}
C {lab_wire.sym} 140 770 0 0 {name=p4 sig_type=std_logic lab=vss}
C {lab_wire.sym} 440 450 0 1 {name=p5 sig_type=std_logic lab=tap1
}
C {lab_wire.sym} 440 470 0 1 {name=p11 sig_type=std_logic lab=tap2
}
C {lab_wire.sym} 440 490 0 1 {name=p12 sig_type=std_logic lab=tap3
}
C {lab_wire.sym} 440 510 0 1 {name=p14 sig_type=std_logic lab=tap4
}
C {lab_wire.sym} 440 530 0 1 {name=p15 sig_type=std_logic lab=tap5
}
C {lab_wire.sym} 440 550 0 1 {name=p16 sig_type=std_logic lab=tap6
}
C {lab_wire.sym} 440 570 0 1 {name=p17 sig_type=std_logic lab=tap7
}
C {lab_wire.sym} 440 590 0 1 {name=p18 sig_type=std_logic lab=tap8
}
C {lab_wire.sym} 440 630 0 1 {name=p19 sig_type=std_logic lab=tap10
}
C {lab_wire.sym} 440 650 0 1 {name=p20 sig_type=std_logic lab=tap11

}
C {lab_wire.sym} 440 670 0 1 {name=p21 sig_type=std_logic lab=tap12
}
C {lab_wire.sym} 440 690 0 1 {name=p22 sig_type=std_logic lab=tap13
}
C {lab_wire.sym} 440 710 0 1 {name=p23 sig_type=std_logic lab=tap14
}
C {lab_wire.sym} 440 730 0 1 {name=p24 sig_type=std_logic lab=tap15
}
C {lab_wire.sym} 440 750 0 1 {name=p25 sig_type=std_logic lab=tap16
}
C {lab_wire.sym} 440 770 0 1 {name=p26 sig_type=std_logic lab=tap17
}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 470 0 0 {name=x4}
C {lab_wire.sym} 860 440 0 1 {name=p27 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 500 0 0 {name=p28 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 480 0 0 {name=p29 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 460 0 0 {name=p30 sig_type=std_logic lab=vrefp
}
C {lab_wire.sym} 560 440 0 0 {name=p31 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 600 0 0 {name=x5}
C {lab_wire.sym} 860 570 0 1 {name=p32 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 630 0 0 {name=p33 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 610 0 0 {name=p34 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 590 0 0 {name=p35 sig_type=std_logic lab=tap17
}
C {lab_wire.sym} 560 570 0 0 {name=p36 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 730 0 0 {name=x6}
C {lab_wire.sym} 860 700 0 1 {name=p37 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 760 0 0 {name=p38 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 740 0 0 {name=p39 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 720 0 0 {name=p40 sig_type=std_logic lab=tap16
}
C {lab_wire.sym} 560 700 0 0 {name=p41 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 860 0 0 {name=x7}
C {lab_wire.sym} 860 830 0 1 {name=p42 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 890 0 0 {name=p43 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 870 0 0 {name=p44 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 850 0 0 {name=p45 sig_type=std_logic lab=tap15
}
C {lab_wire.sym} 560 830 0 0 {name=p46 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 510 0 0 {name=x8}
C {lab_wire.sym} 970 550 0 0 {name=p47 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 710 0 0 {name=x9}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 910 0 0 {name=x10}
C {iopin.sym} -230 730 0 0 {name=pvdd lab=vdd}
C {iopin.sym} -230 750 0 0 {name=pvss lab=vss}
C {ipin.sym} -170 800 0 0 {name=p48 lab=vcm_p}
C {ipin.sym} -170 820 0 0 {name=p49 lab=vcm_n}
C {lab_wire.sym} 970 750 0 0 {name=p50 sig_type=std_logic lab=vss}
C {lab_wire.sym} 970 950 0 0 {name=p51 sig_type=std_logic lab=vss}
C {ipin.sym} -170 860 0 0 {name=p52 lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 630 0 0 {name=x16}
C {lab_wire.sym} 1760 660 0 0 {name=p69 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2060 600 0 1 {name=p74 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 620 0 1 {name=p76 sig_type=std_logic lab=q[62]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 720 0 0 {name=x17}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 810 0 0 {name=x18}
C {lab_wire.sym} 1760 840 0 0 {name=p77 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 750 0 0 {name=p78 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2060 690 0 1 {name=p81 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 780 0 1 {name=p82 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 710 0 1 {name=p83 sig_type=std_logic lab=q[61]}
C {lab_wire.sym} 2120 800 0 1 {name=p84 sig_type=std_logic lab=q[60]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 900 0 0 {name=x19}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 990 0 0 {name=x20}
C {lab_wire.sym} 1760 1020 0 0 {name=p85 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 930 0 0 {name=p86 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2320 870 0 1 {name=p89 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 960 0 1 {name=p90 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 890 0 1 {name=p91 sig_type=std_logic lab=q[59]}
C {lab_wire.sym} 2120 980 0 1 {name=p92 sig_type=std_logic lab=q[58]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 1080 0 0 {name=x21}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 1170 0 0 {name=x22}
C {lab_wire.sym} 1760 1200 0 0 {name=p93 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 1110 0 0 {name=p94 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2060 1050 0 1 {name=p97 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 1140 0 1 {name=p98 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 1070 0 1 {name=p99 sig_type=std_logic lab=q[57]}
C {lab_wire.sym} 2120 1160 0 1 {name=p100 sig_type=std_logic lab=q[56]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 1260 0 0 {name=x23}
C {lab_wire.sym} 2020 1290 0 0 {name=p101 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 1270 0 0 {name=p102 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 1230 0 1 {name=p103 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 1250 0 1 {name=p104 sig_type=std_logic lab=q[55]}
C {lab_wire.sym} 1760 1180 0 0 {name=p55 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 1090 0 0 {name=p63 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 1000 0 0 {name=p64 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2020 910 0 0 {name=p71 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 820 0 0 {name=p72 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 730 0 0 {name=p79 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 640 0 0 {name=p80 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 1440 0 0 {name=x24}
C {lab_wire.sym} 970 1480 0 0 {name=p105 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 1350 0 0 {name=x25}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 1440 0 0 {name=x26}
C {lab_wire.sym} 2060 1320 0 1 {name=p107 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 1410 0 1 {name=p108 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 1340 0 1 {name=p109 sig_type=std_logic lab=q[54]}
C {lab_wire.sym} 2120 1430 0 1 {name=p110 sig_type=std_logic lab=q[53]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 1530 0 0 {name=x27}
C {lab_wire.sym} 2060 1500 0 1 {name=p111 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 1520 0 1 {name=p112 sig_type=std_logic lab=q[52]}
C {lab_wire.sym} 1760 1380 0 0 {name=p113 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 1360 0 0 {name=p114 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 1470 0 0 {name=p115 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 1450 0 0 {name=p116 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 1560 0 0 {name=p117 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 1540 0 0 {name=p118 sig_type=std_logic lab=clk}
C {lab_wire.sym} 100 440 0 1 {name=p119 sig_type=std_logic lab=vrefp
}
C {lab_wire.sym} 70 620 0 1 {name=p120 sig_type=std_logic lab=vrefn
}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 1620 0 0 {name=x11}
C {lab_wire.sym} 2020 1650 0 0 {name=p53 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 1630 0 0 {name=p54 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 1590 0 1 {name=p56 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 1610 0 1 {name=p57 sig_type=std_logic lab=q[51]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 1710 0 0 {name=x12}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 1800 0 0 {name=x13}
C {lab_wire.sym} 2060 1680 0 1 {name=p58 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 1770 0 1 {name=p59 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 1700 0 1 {name=p60 sig_type=std_logic lab=q[50]}
C {lab_wire.sym} 2120 1790 0 1 {name=p61 sig_type=std_logic lab=q[49]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 1890 0 0 {name=x14}
C {lab_wire.sym} 2060 1860 0 1 {name=p62 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 1880 0 1 {name=p65 sig_type=std_logic lab=q[48]}
C {lab_wire.sym} 1760 1740 0 0 {name=p66 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 1720 0 0 {name=p67 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 1830 0 0 {name=p68 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 1810 0 0 {name=p88 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 1920 0 0 {name=p95 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 1900 0 0 {name=p96 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 1980 0 0 {name=x28}
C {lab_wire.sym} 2020 2010 0 0 {name=p121 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 1990 0 0 {name=p122 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 1950 0 1 {name=p123 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 1970 0 1 {name=p124 sig_type=std_logic lab=q[47]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2070 0 0 {name=x29}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2160 0 0 {name=x30}
C {lab_wire.sym} 2060 2040 0 1 {name=p125 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 2130 0 1 {name=p126 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 2060 0 1 {name=p127 sig_type=std_logic lab=q[46]}
C {lab_wire.sym} 2120 2150 0 1 {name=p128 sig_type=std_logic lab=q[45]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2250 0 0 {name=x31}
C {lab_wire.sym} 2060 2220 0 1 {name=p129 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 2240 0 1 {name=p130 sig_type=std_logic lab=q[44]}
C {lab_wire.sym} 1760 2100 0 0 {name=p131 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2080 0 0 {name=p132 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 2190 0 0 {name=p133 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2170 0 0 {name=p134 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 2280 0 0 {name=p135 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2260 0 0 {name=p136 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 2340 0 0 {name=x32}
C {lab_wire.sym} 2020 2370 0 0 {name=p137 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 2350 0 0 {name=p138 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 2310 0 1 {name=p139 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 2330 0 1 {name=p140 sig_type=std_logic lab=q[43]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2430 0 0 {name=x33}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2520 0 0 {name=x34}
C {lab_wire.sym} 2060 2400 0 1 {name=p141 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 2490 0 1 {name=p142 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 2420 0 1 {name=p143 sig_type=std_logic lab=q[42]}
C {lab_wire.sym} 2120 2510 0 1 {name=p144 sig_type=std_logic lab=q[41]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2610 0 0 {name=x35}
C {lab_wire.sym} 2060 2580 0 1 {name=p145 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 2600 0 1 {name=p146 sig_type=std_logic lab=q[40]}
C {lab_wire.sym} 1760 2460 0 0 {name=p147 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2440 0 0 {name=p148 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 2550 0 0 {name=p149 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2530 0 0 {name=p150 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 2640 0 0 {name=p151 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2620 0 0 {name=p152 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 2700 0 0 {name=x36}
C {lab_wire.sym} 2020 2730 0 0 {name=p153 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 2710 0 0 {name=p154 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 2670 0 1 {name=p155 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 2690 0 1 {name=p156 sig_type=std_logic lab=q[39]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2790 0 0 {name=x37}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2880 0 0 {name=x38}
C {lab_wire.sym} 2060 2760 0 1 {name=p157 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 2850 0 1 {name=p158 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 2780 0 1 {name=p159 sig_type=std_logic lab=q[38]}
C {lab_wire.sym} 2120 2870 0 1 {name=p160 sig_type=std_logic lab=q[37]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 2970 0 0 {name=x39}
C {lab_wire.sym} 2060 2940 0 1 {name=p161 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 2960 0 1 {name=p162 sig_type=std_logic lab=q[36]}
C {lab_wire.sym} 1760 2820 0 0 {name=p163 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2800 0 0 {name=p164 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 2910 0 0 {name=p165 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2890 0 0 {name=p166 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 3000 0 0 {name=p167 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 2980 0 0 {name=p168 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 3060 0 0 {name=x40}
C {lab_wire.sym} 2020 3090 0 0 {name=p169 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 3070 0 0 {name=p170 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 3030 0 1 {name=p171 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 3050 0 1 {name=p172 sig_type=std_logic lab=q[35]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 3150 0 0 {name=x41}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 3240 0 0 {name=x42}
C {lab_wire.sym} 2060 3120 0 1 {name=p173 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 3210 0 1 {name=p174 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 3140 0 1 {name=p175 sig_type=std_logic lab=q[34]}
C {lab_wire.sym} 2120 3230 0 1 {name=p176 sig_type=std_logic lab=q[33]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 3330 0 0 {name=x43}
C {lab_wire.sym} 2060 3300 0 1 {name=p177 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 3320 0 1 {name=p178 sig_type=std_logic lab=q[32]}
C {lab_wire.sym} 1760 3180 0 0 {name=p179 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 3160 0 0 {name=p180 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 3270 0 0 {name=p181 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 3250 0 0 {name=p182 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 3360 0 0 {name=p183 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 3340 0 0 {name=p184 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 3420 0 0 {name=x44}
C {lab_wire.sym} 2020 3450 0 0 {name=p185 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 3430 0 0 {name=p186 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 3390 0 1 {name=p187 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 3410 0 1 {name=p188 sig_type=std_logic lab=q[31]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 3510 0 0 {name=x45}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 3600 0 0 {name=x46}
C {lab_wire.sym} 2060 3480 0 1 {name=p189 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 3570 0 1 {name=p190 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 3500 0 1 {name=p191 sig_type=std_logic lab=q[30]}
C {lab_wire.sym} 2120 3590 0 1 {name=p192 sig_type=std_logic lab=q[29]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 3690 0 0 {name=x47}
C {lab_wire.sym} 2060 3660 0 1 {name=p193 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 3680 0 1 {name=p194 sig_type=std_logic lab=q[28]}
C {lab_wire.sym} 1760 3540 0 0 {name=p195 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 3520 0 0 {name=p196 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 3630 0 0 {name=p197 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 3610 0 0 {name=p198 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 3720 0 0 {name=p199 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 3700 0 0 {name=p200 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 3780 0 0 {name=x48}
C {lab_wire.sym} 2020 3810 0 0 {name=p201 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 3790 0 0 {name=p202 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 3750 0 1 {name=p203 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 3770 0 1 {name=p204 sig_type=std_logic lab=q[27]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 3870 0 0 {name=x49}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 3960 0 0 {name=x50}
C {lab_wire.sym} 2060 3840 0 1 {name=p205 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 3930 0 1 {name=p206 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 3860 0 1 {name=p207 sig_type=std_logic lab=q[26]}
C {lab_wire.sym} 2120 3950 0 1 {name=p208 sig_type=std_logic lab=q[25]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 4050 0 0 {name=x51}
C {lab_wire.sym} 2060 4020 0 1 {name=p209 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 4040 0 1 {name=p210 sig_type=std_logic lab=q[24]}
C {lab_wire.sym} 1760 3900 0 0 {name=p211 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 3880 0 0 {name=p212 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 3990 0 0 {name=p213 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 3970 0 0 {name=p214 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 4080 0 0 {name=p215 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 4060 0 0 {name=p216 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 4140 0 0 {name=x52}
C {lab_wire.sym} 2020 4170 0 0 {name=p217 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 4150 0 0 {name=p218 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 4110 0 1 {name=p219 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 4130 0 1 {name=p220 sig_type=std_logic lab=q[23]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 4230 0 0 {name=x53}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 4320 0 0 {name=x54}
C {lab_wire.sym} 2060 4200 0 1 {name=p221 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 4290 0 1 {name=p222 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 4220 0 1 {name=p223 sig_type=std_logic lab=q[22]}
C {lab_wire.sym} 2120 4310 0 1 {name=p224 sig_type=std_logic lab=q[21]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 4410 0 0 {name=x55}
C {lab_wire.sym} 2060 4380 0 1 {name=p225 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 4400 0 1 {name=p226 sig_type=std_logic lab=q[20]}
C {lab_wire.sym} 1760 4260 0 0 {name=p227 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 4240 0 0 {name=p228 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 4350 0 0 {name=p229 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 4330 0 0 {name=p230 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 4440 0 0 {name=p231 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 4420 0 0 {name=p232 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 4500 0 0 {name=x56}
C {lab_wire.sym} 2020 4530 0 0 {name=p233 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 4510 0 0 {name=p234 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 4470 0 1 {name=p235 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 4490 0 1 {name=p236 sig_type=std_logic lab=q[19]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 4590 0 0 {name=x57}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 4680 0 0 {name=x58}
C {lab_wire.sym} 2060 4560 0 1 {name=p237 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 4650 0 1 {name=p238 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 4580 0 1 {name=p239 sig_type=std_logic lab=q[18]}
C {lab_wire.sym} 2120 4670 0 1 {name=p240 sig_type=std_logic lab=q[17]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 4770 0 0 {name=x59}
C {lab_wire.sym} 2060 4740 0 1 {name=p241 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 4760 0 1 {name=p242 sig_type=std_logic lab=q[16]}
C {lab_wire.sym} 1760 4620 0 0 {name=p243 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 4600 0 0 {name=p244 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 4710 0 0 {name=p245 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 4690 0 0 {name=p246 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 4800 0 0 {name=p247 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 4780 0 0 {name=p248 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 4860 0 0 {name=x60}
C {lab_wire.sym} 2020 4890 0 0 {name=p249 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 4870 0 0 {name=p250 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 4830 0 1 {name=p251 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 4850 0 1 {name=p252 sig_type=std_logic lab=q[15]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 4950 0 0 {name=x61}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 5040 0 0 {name=x62}
C {lab_wire.sym} 2060 4920 0 1 {name=p253 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 5010 0 1 {name=p254 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 4940 0 1 {name=p255 sig_type=std_logic lab=q[14]}
C {lab_wire.sym} 2120 5030 0 1 {name=p256 sig_type=std_logic lab=q[13]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 5130 0 0 {name=x63}
C {lab_wire.sym} 2060 5100 0 1 {name=p257 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 5120 0 1 {name=p258 sig_type=std_logic lab=q[12]}
C {lab_wire.sym} 1760 4980 0 0 {name=p259 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 4960 0 0 {name=p260 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 5070 0 0 {name=p261 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 5050 0 0 {name=p262 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 5160 0 0 {name=p263 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 5140 0 0 {name=p264 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 5220 0 0 {name=x64}
C {lab_wire.sym} 2020 5250 0 0 {name=p265 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 5230 0 0 {name=p266 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 5190 0 1 {name=p267 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 5210 0 1 {name=p268 sig_type=std_logic lab=q[11]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 5310 0 0 {name=x65}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 5400 0 0 {name=x66}
C {lab_wire.sym} 2060 5280 0 1 {name=p269 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 5370 0 1 {name=p270 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 5300 0 1 {name=p271 sig_type=std_logic lab=q[10]}
C {lab_wire.sym} 2120 5390 0 1 {name=p272 sig_type=std_logic lab=q[9]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 5490 0 0 {name=x67}
C {lab_wire.sym} 2060 5460 0 1 {name=p273 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 5480 0 1 {name=p274 sig_type=std_logic lab=q[8]}
C {lab_wire.sym} 1760 5340 0 0 {name=p275 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 5320 0 0 {name=p276 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 5430 0 0 {name=p277 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 5410 0 0 {name=p278 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 5520 0 0 {name=p279 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 5500 0 0 {name=p280 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 5580 0 0 {name=x68}
C {lab_wire.sym} 2020 5610 0 0 {name=p281 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 5590 0 0 {name=p282 sig_type=std_logic lab=clk}
C {lab_wire.sym} 2320 5550 0 1 {name=p283 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 5570 0 1 {name=p284 sig_type=std_logic lab=q[7]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 5670 0 0 {name=x69}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 5760 0 0 {name=x70}
C {lab_wire.sym} 2060 5640 0 1 {name=p285 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 5730 0 1 {name=p286 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 5660 0 1 {name=p287 sig_type=std_logic lab=q[6]}
C {lab_wire.sym} 2120 5750 0 1 {name=p288 sig_type=std_logic lab=q[5]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 5850 0 0 {name=x71}
C {lab_wire.sym} 2060 5820 0 1 {name=p289 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 5840 0 1 {name=p290 sig_type=std_logic lab=q[4]}
C {lab_wire.sym} 1760 5700 0 0 {name=p291 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 5680 0 0 {name=p292 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 5790 0 0 {name=p293 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 5770 0 0 {name=p294 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 5880 0 0 {name=p295 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 5860 0 0 {name=p296 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 2170 5940 0 0 {name=x72}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 6030 0 0 {name=x73}
C {lab_wire.sym} 2320 5910 0 1 {name=p297 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2060 6000 0 1 {name=p298 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2380 5930 0 1 {name=p299 sig_type=std_logic lab=q[3]}
C {lab_wire.sym} 2120 6020 0 1 {name=p300 sig_type=std_logic lab=q[2]}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 6120 0 0 {name=x74}
C {lab_wire.sym} 2060 6090 0 1 {name=p301 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 6110 0 1 {name=p302 sig_type=std_logic lab=q[1]}
C {lab_wire.sym} 2020 5970 0 0 {name=p303 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 5950 0 0 {name=p304 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 6060 0 0 {name=p305 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 6040 0 0 {name=p306 sig_type=std_logic lab=clk}
C {lab_wire.sym} 1760 6150 0 0 {name=p307 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 6130 0 0 {name=p308 sig_type=std_logic lab=clk}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 1600 0 0 {name=x75}
C {lab_wire.sym} 860 1570 0 1 {name=p309 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 1630 0 0 {name=p310 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 1610 0 0 {name=p311 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 1590 0 0 {name=p312 sig_type=std_logic lab=tap14
}
C {lab_wire.sym} 560 1570 0 0 {name=p313 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 1800 0 0 {name=x76}
C {lab_wire.sym} 970 1840 0 0 {name=p314 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 1960 0 0 {name=x77}
C {lab_wire.sym} 860 1930 0 1 {name=p315 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 1990 0 0 {name=p316 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 1970 0 0 {name=p317 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 1950 0 0 {name=p318 sig_type=std_logic lab=tap13
}
C {lab_wire.sym} 560 1930 0 0 {name=p319 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 2160 0 0 {name=x78}
C {lab_wire.sym} 970 2200 0 0 {name=p320 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 2320 0 0 {name=x79}
C {lab_wire.sym} 860 2290 0 1 {name=p321 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 2350 0 0 {name=p322 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 2330 0 0 {name=p323 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 2310 0 0 {name=p324 sig_type=std_logic lab=tap12
}
C {lab_wire.sym} 560 2290 0 0 {name=p325 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 2520 0 0 {name=x80}
C {lab_wire.sym} 970 2560 0 0 {name=p326 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 2680 0 0 {name=x81}
C {lab_wire.sym} 860 2650 0 1 {name=p327 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 2710 0 0 {name=p328 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 2690 0 0 {name=p329 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 2670 0 0 {name=p330 sig_type=std_logic lab=tap11
}
C {lab_wire.sym} 560 2650 0 0 {name=p331 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 2880 0 0 {name=x82}
C {lab_wire.sym} 970 2920 0 0 {name=p332 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 3040 0 0 {name=x83}
C {lab_wire.sym} 860 3010 0 1 {name=p333 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 3070 0 0 {name=p334 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 3050 0 0 {name=p335 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 3030 0 0 {name=p336 sig_type=std_logic lab=tap10
}
C {lab_wire.sym} 560 3010 0 0 {name=p337 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 3240 0 0 {name=x84}
C {lab_wire.sym} 970 3280 0 0 {name=p338 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 3400 0 0 {name=x85}
C {lab_wire.sym} 860 3370 0 1 {name=p339 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 3430 0 0 {name=p340 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 3410 0 0 {name=p341 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 3390 0 0 {name=p342 sig_type=std_logic lab=vctr
}
C {lab_wire.sym} 560 3370 0 0 {name=p343 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 3600 0 0 {name=x86}
C {lab_wire.sym} 970 3640 0 0 {name=p344 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 3760 0 0 {name=x87}
C {lab_wire.sym} 860 3730 0 1 {name=p345 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 3790 0 0 {name=p346 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 3770 0 0 {name=p347 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 3750 0 0 {name=p348 sig_type=std_logic lab=tap8
}
C {lab_wire.sym} 560 3730 0 0 {name=p349 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 3960 0 0 {name=x88}
C {lab_wire.sym} 970 4000 0 0 {name=p350 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 4120 0 0 {name=x89}
C {lab_wire.sym} 860 4090 0 1 {name=p351 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 4150 0 0 {name=p352 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 4130 0 0 {name=p353 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 4110 0 0 {name=p354 sig_type=std_logic lab=tap7
}
C {lab_wire.sym} 560 4090 0 0 {name=p355 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 4320 0 0 {name=x90}
C {lab_wire.sym} 970 4360 0 0 {name=p356 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 4480 0 0 {name=x91}
C {lab_wire.sym} 860 4450 0 1 {name=p357 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 4510 0 0 {name=p358 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 4490 0 0 {name=p359 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 4470 0 0 {name=p360 sig_type=std_logic lab=tap6
}
C {lab_wire.sym} 560 4450 0 0 {name=p361 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 4680 0 0 {name=x92}
C {lab_wire.sym} 970 4720 0 0 {name=p362 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 4840 0 0 {name=x93}
C {lab_wire.sym} 860 4810 0 1 {name=p363 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 4870 0 0 {name=p364 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 4850 0 0 {name=p365 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 4830 0 0 {name=p366 sig_type=std_logic lab=tap5
}
C {lab_wire.sym} 560 4810 0 0 {name=p367 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 5040 0 0 {name=x94}
C {lab_wire.sym} 970 5080 0 0 {name=p368 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 5200 0 0 {name=x95}
C {lab_wire.sym} 860 5170 0 1 {name=p369 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 5230 0 0 {name=p370 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 5210 0 0 {name=p371 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 5190 0 0 {name=p372 sig_type=std_logic lab=tap4
}
C {lab_wire.sym} 560 5170 0 0 {name=p373 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 5400 0 0 {name=x96}
C {lab_wire.sym} 970 5440 0 0 {name=p374 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 5560 0 0 {name=x97}
C {lab_wire.sym} 860 5530 0 1 {name=p375 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 5590 0 0 {name=p376 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 5570 0 0 {name=p377 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 5550 0 0 {name=p378 sig_type=std_logic lab=tap3
}
C {lab_wire.sym} 560 5530 0 0 {name=p379 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 5760 0 0 {name=x98}
C {lab_wire.sym} 970 5800 0 0 {name=p380 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 5920 0 0 {name=x99}
C {lab_wire.sym} 860 5890 0 1 {name=p381 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 5950 0 0 {name=p382 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 5930 0 0 {name=p383 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 5910 0 0 {name=p384 sig_type=std_logic lab=tap2
}
C {lab_wire.sym} 560 5890 0 0 {name=p385 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 6120 0 0 {name=x100}
C {lab_wire.sym} 970 6160 0 0 {name=p386 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 6280 0 0 {name=x101}
C {lab_wire.sym} 860 6250 0 1 {name=p387 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 6310 0 0 {name=p388 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 6290 0 0 {name=p389 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 6270 0 0 {name=p390 sig_type=std_logic lab=tap1
}
C {lab_wire.sym} 560 6250 0 0 {name=p391 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/interp4.sym} 1120 6480 0 0 {name=x102}
C {lab_wire.sym} 970 6520 0 0 {name=p392 sig_type=std_logic lab=vss}
C {/headless/eda/designs/gf180_flash_adc/preamp.sym} 710 6640 0 0 {name=x103}
C {lab_wire.sym} 860 6610 0 1 {name=p393 sig_type=std_logic lab=vdd
}
C {lab_wire.sym} 560 6670 0 0 {name=p394 sig_type=std_logic lab=vss}
C {lab_wire.sym} 560 6650 0 0 {name=p395 sig_type=std_logic lab=nbias
}
C {lab_wire.sym} 560 6630 0 0 {name=p396 sig_type=std_logic lab=vrefn
}
C {lab_wire.sym} 560 6610 0 0 {name=p397 sig_type=std_logic lab=vcm_p}
C {/headless/eda/designs/gf180_flash_adc/strongarm.sym} 1910 6210 0 0 {name=x15}
C {lab_wire.sym} 2060 6180 0 1 {name=p70 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2120 6200 0 1 {name=p73 sig_type=std_logic lab=q[0]}
C {lab_wire.sym} 1760 6240 0 0 {name=p75 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1760 6220 0 0 {name=p87 sig_type=std_logic lab=clk}
C {opin.sym} -190 900 0 0 {name=p106 lab=q[62:0]}
C {symbols/cap_nmos_03v3_b.sym} 290 930 0 0 {name=C1
W=16e-6
L=16e-6
model=cap_nmos_03v3_b
spiceprefix=X
m=1}
C {lab_wire.sym} 290 880 0 0 {name=p398 sig_type=std_logic lab=vctr
}
C {lab_wire.sym} 290 980 0 0 {name=p399 sig_type=std_logic lab=vss
}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1680 890 0 0 {name=x104}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 1250 0 0 {name=x105}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 1610 0 0 {name=x106}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 1970 0 0 {name=x107}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 2330 0 0 {name=x108}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 2690 0 0 {name=x109}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 3050 0 0 {name=x110}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 3410 0 0 {name=x111}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 3770 0 0 {name=x112}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 4130 0 0 {name=x113}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 4490 0 0 {name=x114}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 4850 0 0 {name=x115}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 5210 0 0 {name=x116}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 5570 0 0 {name=x117}
C {/headless/eda/designs/gf180_flash_adc/strongarm_pre.sym} 1650 5930 0 0 {name=x118}
C {lab_wire.sym} 1800 5950 0 1 {name=p400 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 5590 0 1 {name=p401 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 5230 0 1 {name=p402 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 4870 0 1 {name=p403 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 4510 0 1 {name=p404 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 4150 0 1 {name=p405 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 3790 0 1 {name=p406 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 3430 0 1 {name=p407 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 3070 0 1 {name=p408 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 2710 0 1 {name=p409 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 2350 0 1 {name=p410 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 1990 0 1 {name=p411 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 1630 0 1 {name=p412 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 1270 0 1 {name=p413 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1830 910 0 1 {name=p414 sig_type=std_logic lab=vss}
