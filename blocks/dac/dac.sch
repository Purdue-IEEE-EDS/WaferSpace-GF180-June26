v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -35 -222.5 0 0 {name=p1 lab=Vdd}
C {opin.sym} 6.25 -305 0 0 {name=p9 lab=VOUT_I_P}
C {ipin.sym} -35 -303.75 0 0 {name=p2 lab=DDS_I[35:0]}
C {opin.sym} 6.25 -285 0 0 {name=p4 lab=VOUT_I_N}
C {ipin.sym} -35 -283.75 0 0 {name=p6 lab=DDS_Q[35:0]}
C {ipin.sym} -35 -263.75 0 0 {name=p7 lab=CLK}
C {ipin.sym} -35 -242.5 0 0 {name=p8 lab=IREF_MASTER_10UA}
C {lab_pin.sym} -120 -83.75 2 1 {name=p10 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} -120 -143.75 2 1 {name=p12 sig_type=std_logic lab=DDS_I[35:0]}
C {lab_pin.sym} 80 -123.75 0 1 {name=p20 sig_type=std_logic lab=VOUT_I_N}
C {dac_iq.sym} -20 -113.75 0 0 {name=x_dac_i}
C {lab_pin.sym} -120 -103.75 2 1 {name=p14 sig_type=std_logic lab=CLK}
C {lab_pin.sym} -120 -123.75 2 1 {name=p15 sig_type=std_logic lab=IREF_MASTER_10UA}
C {lab_pin.sym} 80 -143.75 0 1 {name=p16 sig_type=std_logic lab=VOUT_I_P}
C {lab_pin.sym} -121.25 43.75 2 1 {name=p11 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} -121.25 -16.25 2 1 {name=p13 sig_type=std_logic lab=DDS_Q[35:0]}
C {lab_pin.sym} 78.75 3.75 0 1 {name=p17 sig_type=std_logic lab=VOUT_Q_N}
C {dac_iq.sym} -21.25 13.75 0 0 {name=x_dac_q}
C {lab_pin.sym} -121.25 3.75 2 1 {name=p19 sig_type=std_logic lab=IREF_MASTER_10UA}
C {lab_pin.sym} 78.75 -16.25 0 1 {name=p21 sig_type=std_logic lab=VOUT_Q_P}
C {lab_pin.sym} -121.25 23.75 2 1 {name=p18 sig_type=std_logic lab=CLK}
C {opin.sym} 5 -262.5 0 0 {name=p3 lab=VOUT_Q_P}
C {opin.sym} 5 -242.5 0 0 {name=p5 lab=VOUT_Q_N}
