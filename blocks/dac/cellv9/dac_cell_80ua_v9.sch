v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {10uA local mirror} 2027.5 753.75 0 0 0.25 0.25 {}
T {10uA} 2495 797.5 0 0 0.25 0.25 {}
N 1360 795 1360 890 {lab=Vcx}
N 1360 795 1440 795 {lab=Vcx}
N 1140 795 1280 795 {lab=Vcx}
N 1000 795 1140 795 {lab=Vcx}
N 1280 795 1360 795 {lab=Vcx}
N 1440 795 1580 795 {lab=Vcx}
N 1720 795 1860 795 {lab=Vcx}
N 860 795 1000 795 {lab=Vcx}
N 1290 985 1290 1030 {lab=VxP}
N 1360 890 1435 890 {lab=Vcx}
N 1290 890 1360 890 {lab=Vcx}
N 1430 955 1435 955 {lab=Vdd}
N 1285 955 1290 955 {lab=Vdd}
N 1290 1060 1295 1060 {lab=Vdd}
N 1430 1060 1435 1060 {lab=Vdd}
N 1545 1152.5 1550 1152.5 {lab=Vdd}
N 1545 1197.5 1545 1212.5 {lab=#net1}
N 1545 1177.5 1545 1197.5 {lab=#net1}
N 1545 1107.5 1545 1122.5 {lab=Vdd}
N 1545 1272.5 1545 1287.5 {lab=0}
N 1430 1197.5 1435 1197.5 {lab=Vdd}
N 1435 1157.5 1435 1167.5 {lab=VoutN}
N 1435 1237.5 1435 1287.5 {lab=VoutN}
N 1475 1197.5 1545 1197.5 {lab=#net1}
N 1175 1152.5 1180 1152.5 {lab=Vdd}
N 1180 1197.5 1180 1212.5 {lab=#net2}
N 1180 1177.5 1180 1197.5 {lab=#net2}
N 1180 1107.5 1180 1122.5 {lab=Vdd}
N 1180 1272.5 1180 1287.5 {lab=0}
N 1290 1197.5 1295 1197.5 {lab=Vdd}
N 1290 1157.5 1290 1167.5 {lab=VoutP}
N 1290 1237.5 1290 1292.5 {lab=VoutP}
N 1340 1157.5 1340 1237.5 {lab=VoutP}
N 1180 1197.5 1250 1197.5 {lab=#net2}
N 1290 1237.5 1340 1237.5 {lab=VoutP}
N 1290 1157.5 1340 1157.5 {lab=VoutP}
N 1385 1237.5 1435 1237.5 {lab=VoutN}
N 1385 1157.5 1435 1157.5 {lab=VoutN}
N 1385 1157.5 1385 1237.5 {lab=VoutN}
N 1290 1090 1290 1157.5 {lab=VoutP}
N 822.5 1107.5 822.5 1122.5 {lab=VcbRef}
N 1435 985 1435 1030 {lab=VxN}
N 1435 1090 1435 1157.5 {lab=VoutN}
N 275 812.5 280 812.5 {lab=0}
N 275 652.5 275 682.5 {lab=#net3}
N 210 607.5 235 607.5 {lab=VinPDr}
N 210 712.5 235 712.5 {lab=VinPDr}
N 210 812.5 235 812.5 {lab=VinPDr}
N 620 812.5 645 812.5 {lab=VinNDr}
N 585 652.5 585 682.5 {lab=#net4}
N 500 557.5 585 557.5 {lab=VH}
N 625 607.5 645 607.5 {lab=VinNDr}
N 625 712.5 645 712.5 {lab=VinNDr}
N 645 667.5 645 712.5 {lab=VinNDr}
N 350 607.5 355 607.5 {lab=Vdd}
N 495 607.5 505 607.5 {lab=Vdd}
N 495 812.5 500 812.5 {lab=Vdd}
N 380 812.5 385 812.5 {lab=Vdd}
N 210 667.5 210 712.5 {lab=VinPDr}
N 275 557.5 355 557.5 {lab=VH}
N 585 742.5 585 782.5 {lab=Vg1N}
N 275 842.5 275 877.5 {lab=VL}
N 380 842.5 380 877.5 {lab=VL}
N 495 842.5 495 877.5 {lab=VL}
N 585 842.5 585 877.5 {lab=VL}
N 355 557.5 500 557.5 {lab=VH}
N 495 877.5 585 877.5 {lab=VL}
N 380 877.5 495 877.5 {lab=VL}
N 270 607.5 275 607.5 {lab=Vdd}
N 355 637.5 355 652.5 {lab=#net3}
N 275 652.5 355 652.5 {lab=#net3}
N 275 637.5 275 652.5 {lab=#net3}
N 210 607.5 210 667.5 {lab=VinPDr}
N 585 637.5 585 652.5 {lab=#net4}
N 645 607.5 645 667.5 {lab=VinNDr}
N 585 607.5 590 607.5 {lab=Vdd}
N 500 652.5 585 652.5 {lab=#net4}
N 275 742.5 275 782.5 {lab=Vg1P}
N 210 712.5 210 812.5 {lab=VinPDr}
N 645 712.5 645 812.5 {lab=VinNDr}
N 275 742.5 380 742.5 {lab=Vg1P}
N 495 742.5 585 742.5 {lab=Vg1N}
N 380 742.5 495 782.5 {lab=Vg1P}
N 380 782.5 495 742.5 {lab=Vg1N}
N 340 812.5 340 852.5 {lab=VinPDr}
N 210 852.5 340 852.5 {lab=VinPDr}
N 210 812.5 210 852.5 {lab=VinPDr}
N 535 812.5 535 852.5 {lab=VinNDr}
N 535 852.5 645 852.5 {lab=VinNDr}
N 645 812.5 645 852.5 {lab=VinNDr}
N 585 557.5 585 577.5 {lab=VH}
N 500 557.5 500 577.5 {lab=VH}
N 355 557.5 355 577.5 {lab=VH}
N 275 557.5 275 577.5 {lab=VH}
N 580 812.5 585 812.5 {lab=0}
N 585 712.5 590 712.5 {lab=Vdd}
N 270 712.5 275 712.5 {lab=Vdd}
N 395 607.5 415 607.5 {lab=VinNDr}
N 415 607.5 470 667.5 {lab=VinNDr}
N 500 637.5 500 652.5 {lab=#net4}
N 440 607.5 460 607.5 {lab=VinPDr}
N 390 667.5 440 607.5 {lab=VinPDr}
N 1435 890 1435 925 {lab=Vcx}
N 1290 890 1290 925 {lab=Vcx}
N 210 667.5 390 667.5 {lab=VinPDr}
N 470 667.5 645 667.5 {lab=VinNDr}
N 1140 1152.5 1140 1242.5 {lab=Vg1P}
N 1585 1152.5 1585 1245 {lab=Vg1N}
N 1580 560 1580 595 {lab=Vdd}
N 1580 655 1580 675 {lab=#net5}
N 1580 735 1580 795 {lab=Vcx}
N 1720 560 1720 595 {lab=Vdd}
N 1720 655 1720 675 {lab=#net6}
N 1720 735 1720 795 {lab=Vcx}
N 1860 560 1860 595 {lab=Vdd}
N 1860 655 1860 675 {lab=#net7}
N 1860 735 1860 795 {lab=Vcx}
N 1440 560 1440 595 {lab=Vdd}
N 1440 655 1440 675 {lab=#net8}
N 1440 735 1440 795 {lab=Vcx}
N 1000 560 1000 595 {lab=Vdd}
N 1000 655 1000 675 {lab=#net9}
N 1000 735 1000 795 {lab=Vcx}
N 1140 560 1140 595 {lab=Vdd}
N 1140 655 1140 675 {lab=#net10}
N 1140 735 1140 795 {lab=Vcx}
N 1280 560 1280 595 {lab=Vdd}
N 1280 655 1280 675 {lab=#net11}
N 1280 735 1280 795 {lab=Vcx}
N 860 560 860 595 {lab=Vdd}
N 860 655 860 675 {lab=#net12}
N 860 735 860 795 {lab=Vcx}
N 1290 1227.5 1290 1237.5 {lab=VoutP}
N 1435 1227.5 1435 1237.5 {lab=VoutN}
N 275 877.5 380 877.5 {lab=VL}
N 1580 795 1720 795 {lab=Vcx}
N 2163.75 847.5 2163.75 872.5 {lab=#net13}
N 2203.75 697.5 2263.75 697.5 {lab=VPMir}
N 2163.75 727.5 2163.75 737.5 {lab=VPMir}
N 2203.75 697.5 2203.75 737.5 {lab=VPMir}
N 2163.75 932.5 2163.75 962.5 {lab=0}
N 2163.75 737.5 2163.75 787.5 {lab=VPMir}
N 2203.75 612.5 2263.75 612.5 {lab=VPCas}
N 2163.75 642.5 2163.75 667.5 {lab=#net14}
N 2163.75 737.5 2203.75 737.5 {lab=VPMir}
N 2163.75 557.5 2163.75 583.75 {lab=Vdd}
N 987.5 977.5 987.5 1042.5 {lab=VcbP}
N 987.5 1042.5 1107.5 1042.5 {lab=VcbP}
N 1107.5 967.5 1107.5 1042.5 {lab=VcbP}
N 1750 965 1750 1025 {lab=VcbN}
N 1630 955 1630 1025 {lab=VcbN}
N 1630 1025 1750 1025 {lab=VcbN}
N 7.5 692.5 15 692.5 {lab=VinNDr}
N 7.5 602.5 15 602.5 {lab=VinPDr}
N 2360 767.5 2360 787.5 {lab=#net15}
N 2360 847.5 2360 872.5 {lab=#net16}
N 2360 932.5 2360 962.5 {lab=0}
N 2360 692.5 2360 707.5 {lab=Vdd}
N 2400 737.5 2400 767.5 {lab=#net15}
N 2360 767.5 2400 767.5 {lab=#net15}
N 2397.5 737.5 2400 737.5 {lab=#net15}
N 2485 692.5 2485 707.5 {lab=Vdd}
N 2485 835 2525 835 {lab=IB10}
N 2485 835 2485 836.25 {lab=IB10}
N 2485 766.25 2485 835 {lab=IB10}
N 2522.5 865 2525 865 {lab=IB10}
N 2360 737.5 2363.75 737.5 {lab=Vdd}
N 2481.25 737.5 2485 737.5 {lab=Vdd}
N 2483.75 865 2488.75 865 {lab=0}
N 2525 835 2525 865 {lab=IB10}
N 2525 865 2550 865 {lab=IB10}
N 2400 817.5 2400 848.75 {lab=VNMir}
N 2400 848.75 2400 856.25 {lab=VNMir}
N 2203.75 817.5 2203.75 856.25 {lab=VNMir}
N 2400 902.5 2400 940 {lab=VNCas}
N 2203.75 902.5 2203.75 940 {lab=VNCas}
N 2485 895 2485 926.25 {lab=0}
N 2485 926.25 2485 927.5 {lab=0}
N 2400 737.5 2445 737.5 {lab=#net15}
N 2358.75 692.5 2485 692.5 {lab=Vdd}
N 2203.75 856.25 2400 856.25 {lab=VNMir}
N 2203.75 940 2400 940 {lab=VNCas}
C {param.sym} 237.5 507.5 0 0 {name=s8 value="cmLw=0.4u"
}
C {param.sym} 237.5 487.5 0 0 {name=s10 value="cmHw=0.7u"
}
C {param.sym} 467.5 507.5 0 0 {name=s11 value="cmLfbw=1.0u"
}
C {param.sym} 467.5 487.5 0 0 {name=s14 value="cmHfbw=0.22u"
}
C {symbols/pfet_03v3.sym} 1270 955 0 0 {name=M20
L=0.28u
W=\{cswW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1455 955 0 1 {name=M21
L=0.28u
W=\{cswW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1290 955 0 1 {name=p41 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1430 955 0 0 {name=p47 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1270 1060 0 0 {name=M22
L=0.28u
W=\{cbufW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1295 1060 0 1 {name=p53 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1455 1060 0 1 {name=M23
L=0.28u
W=\{cbufW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1430 1060 0 0 {name=p58 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1565 1152.5 0 1 {name=M24
L=0.28u
W=\{invPw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1545 1152.5 0 0 {name=p63 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1545 1242.5 1 1 {name=l2 lab=0}
C {symbols/nfet_03v3.sym} 1565 1242.5 0 1 {name=M34
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1545 1287.5 0 0 {name=l6 lab=0}
C {symbols/pfet_03v3.sym} 1455 1197.5 0 1 {name=M35
L=0.28u
W=\{dummyW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1430 1197.5 0 0 {name=p68 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1160 1152.5 0 0 {name=M36
L=0.28u
W=\{invPw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1180 1152.5 0 1 {name=p73 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1180 1242.5 3 0 {name=l4 lab=0}
C {symbols/nfet_03v3.sym} 1160 1242.5 0 0 {name=M37
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1180 1287.5 0 1 {name=l5 lab=0}
C {symbols/pfet_03v3.sym} 1270 1197.5 0 0 {name=M38
L=0.28u
W=\{dummyW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1295 1197.5 0 1 {name=p76 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 1180 1107.5 0 0 {name=p78 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 1545 1107.5 0 0 {name=p79 sig_type=std_logic lab=Vdd}
C {opin.sym} 480 252.5 0 0 {name=p80 lab=VoutP}
C {opin.sym} 482.5 277.5 0 0 {name=p81 lab=VoutN}
C {gnd.sym} 822.5 1182.5 0 0 {name=l8 lab=0}
C {vsource.sym} 822.5 1152.5 0 0 {name=VcbRef3 value=\{Vcbias\} savecurrent=true}
C {lab_pin.sym} 822.5 1107.5 0 1 {name=p82 sig_type=std_logic lab=VcbRef}
C {lab_pin.sym} 1475 1060 2 0 {name=p83 sig_type=std_logic lab=VcbN}
C {ipin.sym} 437.5 252.5 0 0 {name=p84 lab=VinP}
C {ipin.sym} 440 280 0 0 {name=p85 lab=VinN}
C {param.sym} 762.5 1090 0 0 {name=s3 value="VcBias=0.84"
}
C {param.sym} 2117.5 467.5 0 0 {name=s5 value="casW=4u"
}
C {lab_pin.sym} 1360 847.5 2 1 {name=p86 sig_type=std_logic lab=Vcx}
C {lab_pin.sym} 1290 1007.5 2 1 {name=p87 sig_type=std_logic lab=VxP}
C {lab_pin.sym} 1435 1007.5 0 0 {name=p88 sig_type=std_logic lab=VxN}
C {lab_pin.sym} 1250 1060 0 0 {name=p92 sig_type=std_logic lab=VcbP}
C {symbols/pfet_03v3.sym} 255 607.5 0 0 {name=M39
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 255 712.5 0 0 {name=M40
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 255 812.5 0 0 {name=M41
L=0.28u
W=\{cmLw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 280 812.5 3 0 {name=l10 lab=0}
C {symbols/pfet_03v3.sym} 375 607.5 0 1 {name=M42
L=0.28u
W=\{cmHfbW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 605 607.5 0 1 {name=M43
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 605 712.5 0 1 {name=M44
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 605 812.5 0 1 {name=M45
L=0.28u
W=\{cmLw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 580 812.5 1 1 {name=l12 lab=0}
C {symbols/pfet_03v3.sym} 480 607.5 0 0 {name=M46
L=0.28u
W=\{cmHfbW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 360 812.5 0 0 {name=M47
L=0.28u
W=\{cmLfbw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 515 812.5 0 1 {name=M48
L=0.28u
W=\{cmLfbw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 385 812.5 0 1 {name=p96 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 500 812.5 0 0 {name=p97 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 380 742.5 0 0 {name=p98 sig_type=std_logic lab=Vg1P}
C {lab_wire.sym} 565 742.5 0 0 {name=p99 sig_type=std_logic lab=Vg1N}
C {lab_wire.sym} 350 607.5 0 0 {name=p100 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 410 557.5 0 1 {name=p101 sig_type=std_logic lab=VH}
C {lab_wire.sym} 275 607.5 0 1 {name=p102 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 500 607.5 0 1 {name=p103 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 585 607.5 0 0 {name=p104 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 275 712.5 0 1 {name=p105 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 585 712.5 0 0 {name=p106 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 430 877.5 0 1 {name=p110 sig_type=std_logic lab=VL}
C {lab_pin.sym} 1250 955 2 1 {name=p117 sig_type=std_logic lab=Vg1P}
C {lab_pin.sym} 1475 955 0 1 {name=p125 sig_type=std_logic lab=Vg1N}
C {lab_pin.sym} 1290 1292.5 2 0 {name=p127 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 1435 1287.5 0 0 {name=p128 sig_type=std_logic lab=VoutN}
C {ipin.sym} 440 377.5 0 0 {name=p129 lab=Vdd}
C {ipin.sym} 440 305 0 0 {name=p130 lab=VPCas}
C {ipin.sym} 440 332.5 0 0 {name=p131 lab=VNCas}
C {lab_pin.sym} 1140 1195 2 1 {name=p135 sig_type=std_logic lab=Vg1P}
C {lab_pin.sym} 1585 1195 0 1 {name=p136 sig_type=std_logic lab=Vg1N}
C {param.sym} 1532.5 487.5 0 0 {name=s15 value="dummyW=1.0u"
}
C {param.sym} 1532.5 462.5 0 0 {name=s16 value="invPW=0.5u"
}
C {param.sym} 1272.5 467.5 0 0 {name=s17 value="cswW=3.0u"
}
C {param.sym} 1272.5 487.5 0 0 {name=s18 value="cbufW=3.2u"
}
C {cellv9/clamp.sym} 390 960 0 0 {name=x1}
C {lab_wire.sym} 490 950 0 1 {name=p4 sig_type=std_logic lab=VH}
C {lab_wire.sym} 490 970 0 1 {name=p5 sig_type=std_logic lab=VL}
C {lab_wire.sym} 290 950 0 0 {name=p6 sig_type=std_logic lab=Vdd}
C {param.sym} 2120 442.5 0 0 {name=s1 value="mirW=4u"
}
C {param.sym} 2120 420 0 0 {name=s2 value="mirL=1u"
}
C {param.sym} 2122.5 490 0 0 {name=s4 value="casL=1u"
}
C {symbols/pfet_03v3.sym} 1560 625 0 0 {name=M4
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1560 705 0 0 {name=M7
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1580 625 0 1 {name=p19 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1580 705 0 1 {name=p24 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1540 705 2 1 {name=p25 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1540 625 2 1 {name=p26 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1580 560 2 1 {name=p27 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1700 625 0 0 {name=M9
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1700 705 0 0 {name=M10
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1720 625 0 1 {name=p28 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1720 705 0 1 {name=p29 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1680 705 2 1 {name=p30 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1680 625 2 1 {name=p31 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1720 560 2 1 {name=p32 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1840 625 0 0 {name=M11
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1840 705 0 0 {name=M12
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1860 625 0 1 {name=p33 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1860 705 0 1 {name=p34 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1820 705 2 1 {name=p35 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1820 625 2 1 {name=p36 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1860 560 2 1 {name=p37 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1420 625 0 0 {name=M13
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1420 705 0 0 {name=M14
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1440 625 0 1 {name=p38 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1440 705 0 1 {name=p39 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1400 705 2 1 {name=p40 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1400 625 2 1 {name=p42 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1440 560 2 1 {name=p43 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 980 625 0 0 {name=M1
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 980 705 0 0 {name=M5
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1000 625 0 1 {name=p1 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1000 705 0 1 {name=p2 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 960 705 2 1 {name=p3 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 960 625 2 1 {name=p7 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1000 560 2 1 {name=p8 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1120 625 0 0 {name=M6
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1120 705 0 0 {name=M8
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1140 625 0 1 {name=p20 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1140 705 0 1 {name=p21 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1100 705 2 1 {name=p22 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1100 625 2 1 {name=p23 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1140 560 2 1 {name=p44 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1260 625 0 0 {name=M15
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1260 705 0 0 {name=M16
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1280 625 0 1 {name=p45 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1280 705 0 1 {name=p46 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1240 705 2 1 {name=p48 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1240 625 2 1 {name=p49 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1280 560 2 1 {name=p50 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 840 625 0 0 {name=M17
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 840 705 0 0 {name=M18
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 860 625 0 1 {name=p51 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 860 705 0 1 {name=p52 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 820 705 2 1 {name=p54 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 820 625 2 1 {name=p55 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 860 560 2 1 {name=p56 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2163.75 817.5 1 1 {name=l9 lab=0}
C {symbols/nfet_03v3.sym} 2183.75 817.5 0 1 {name=M2
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2183.75 697.5 0 1 {name=M3
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2163.75 697.5 0 0 {name=p14 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2163.75 902.5 1 1 {name=l11 lab=0}
C {symbols/nfet_03v3.sym} 2183.75 902.5 0 1 {name=M19
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2163.75 962.5 0 1 {name=l13 lab=0}
C {symbols/pfet_03v3.sym} 2183.75 612.5 0 1 {name=M25
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2163.75 612.5 0 0 {name=p15 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2228.75 757.5 0 1 {name=l23 lab=0}
C {lab_pin.sym} 2163.75 557.5 1 0 {name=p16 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2203.75 902.5 0 1 {name=p17 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 2203.75 817.5 0 1 {name=p18 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 2262.5 697.5 2 0 {name=p57 sig_type=std_logic lab=VPMir}
C {ipin.sym} 440 355 0 0 {name=p60 lab=VNMir}
C {lab_pin.sym} 1107.5 967.5 2 0 {name=p9 sig_type=std_logic lab=VcbP}
C {lab_pin.sym} 987.5 927.5 0 0 {name=p10 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 987.5 947.5 2 1 {name=p11 sig_type=std_logic lab=VcbRef}
C {cellv9/ota5_ab_buf_v1.sym} 1007.5 1097.5 0 0 {name=x2}
C {lab_pin.sym} 1630 955 0 0 {name=p12 sig_type=std_logic lab=VcbN}
C {lab_pin.sym} 1750 915 2 0 {name=p13 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1750 935 0 1 {name=p61 sig_type=std_logic lab=VcbRef}
C {cellv9/ota5_ab_buf_v1.sym} 1730 1085 0 1 {name=x3}
C {lab_pin.sym} 2263.75 612.5 2 0 {name=p65 sig_type=std_logic lab=VPCas}
C {ammeter.sym} -82.5 692.5 3 0 {name=VinN savecurrent=true spice_ignore=0}
C {common/cmos_buf.sym} -172.5 702.5 0 0 {name=x5}
C {lab_pin.sym} -212.5 682.5 2 1 {name=p59 sig_type=std_logic lab=VinN}
C {lab_pin.sym} -212.5 702.5 2 1 {name=p62 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 15 692.5 0 1 {name=p64 sig_type=std_logic lab=VinNDr}
C {ammeter.sym} -82.5 602.5 3 0 {name=VinP savecurrent=true spice_ignore=0}
C {common/cmos_buf.sym} -172.5 612.5 0 0 {name=x4}
C {lab_pin.sym} -212.5 592.5 2 1 {name=p66 sig_type=std_logic lab=VinP}
C {lab_pin.sym} -212.5 612.5 2 1 {name=p67 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 15 602.5 0 1 {name=p69 sig_type=std_logic lab=VinPDr}
C {lab_pin.sym} 210 642.5 2 1 {name=p70 sig_type=std_logic lab=VinPDr}
C {lab_pin.sym} 645 637.5 2 0 {name=p71 sig_type=std_logic lab=VinNDr}
C {gnd.sym} 2360 817.5 1 1 {name=l1 lab=0}
C {symbols/nfet_03v3.sym} 2380 817.5 0 1 {name=M26
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2360 902.5 1 1 {name=l3 lab=0}
C {symbols/nfet_03v3.sym} 2380 902.5 0 1 {name=M27
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2360 962.5 0 1 {name=l7 lab=0}
C {lab_pin.sym} 2400 902.5 0 1 {name=p72 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 2400 817.5 0 1 {name=p74 sig_type=std_logic lab=VNMir}
C {symbols/pfet_03v3.sym} 2380 737.5 0 1 {name=M28
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2360 692.5 1 0 {name=p75 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 2465 737.5 0 0 {name=M29
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2505 865 0 1 {name=M30
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2485 927.5 0 1 {name=l14 lab=0}
C {lab_pin.sym} 2550 865 2 0 {name=p89 sig_type=std_logic lab=IB10}
C {lab_pin.sym} 1750 895 0 1 {name=p90 sig_type=std_logic lab=IB10}
C {lab_pin.sym} 987.5 907.5 0 0 {name=p91 sig_type=std_logic lab=IB10}
C {lab_pin.sym} 2360 737.5 0 0 {name=p93 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2483.75 737.5 2 0 {name=p94 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2483.75 865 1 1 {name=l15 lab=0}
C {gnd.sym} 2538.75 925 0 1 {name=l16 lab=0}
C {symbols/ppolyf_u_1k.sym} -22.5 692.5 1 0 {name=R3
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} -22.5 672.5 0 0 {name=p95 sig_type=std_logic lab=Vdd}
C {symbols/ppolyf_u_1k.sym} -22.5 602.5 3 0 {name=R2
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} -22.5 622.5 2 0 {name=p107 sig_type=std_logic lab=Vdd}
C {symbols/cap_mim_analog.sym} 2228.75 727.5 0 0 {name=C4
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1}
C {symbols/cap_mim_analog.sym} 2538.75 895 0 0 {name=C2
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1}
C {lab_pin.sym} 2238.75 510 0 1 {name=p77 sig_type=std_logic lab=Vdd}
C {symbols/cap_mim_analog.sym} 2238.75 540 0 0 {name=C7
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1
C=1pF}
C {gnd.sym} 2238.75 570 0 0 {name=Data2 lab=0
value="PULSE(3.3 0 \{clk*0.5\} 30ps 30ps \{clk*1\} \{clk*2\})"
}
