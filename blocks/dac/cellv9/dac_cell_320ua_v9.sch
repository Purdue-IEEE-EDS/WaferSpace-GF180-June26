v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lab_pin.sym} 160 -15 2 1 {name=p32 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 160 5 2 1 {name=p46 sig_type=std_logic lab=VinN}
C {cellv9/dac_cell_80ua_v9.sym} 260 25 0 0 {name=x1[3:0]}
C {lab_pin.sym} 360 5 0 1 {name=p15 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 360 -15 0 1 {name=p16 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 160 65 2 1 {name=p1 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 160 45 2 1 {name=p6 sig_type=std_logic lab=IREF_10UA[3:0]}
C {lab_pin.sym} 160 25 2 1 {name=p3 sig_type=std_logic lab=VCAS_IN}
C {opin.sym} 32.5 -215 0 0 {name=p2 lab=VoutP}
C {opin.sym} 35 -190 0 0 {name=p5 lab=VoutN}
C {ipin.sym} -10 -215 0 0 {name=p17 lab=VinP}
C {ipin.sym} -7.5 -187.5 0 0 {name=p18 lab=VinN}
C {ipin.sym} -10 -112.5 0 0 {name=p19 lab=Vdd}
C {ipin.sym} -7.5 -162.5 0 0 {name=p20 lab=VCAS_IN}
C {ipin.sym} -8.75 -137.5 0 0 {name=p60 lab=IREF_10UA[3:0]}
