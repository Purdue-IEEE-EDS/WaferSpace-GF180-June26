v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lab_pin.sym} 160 -15 2 1 {name=p32 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 160 5 2 1 {name=p46 sig_type=std_logic lab=VinN}
C {cellv9/dac_cell_80ua_v9.sym} 260 35 0 0 {name=x5}
C {lab_pin.sym} 360 5 0 1 {name=p15 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 360 -15 0 1 {name=p16 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 160 85 2 1 {name=p1 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 160 65 2 1 {name=p6 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 160 45 2 1 {name=p12 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 160 25 2 1 {name=p3 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 160 130 2 1 {name=p4 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 160 150 2 1 {name=p7 sig_type=std_logic lab=VinN}
C {cellv9/dac_cell_80ua_v9.sym} 260 180 0 0 {name=x2}
C {lab_pin.sym} 360 150 0 1 {name=p8 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 360 130 0 1 {name=p9 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 160 230 2 1 {name=p10 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 160 210 2 1 {name=p11 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 160 190 2 1 {name=p13 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 160 170 2 1 {name=p14 sig_type=std_logic lab=VPCas}
C {opin.sym} 32.5 -215 0 0 {name=p2 lab=VoutP}
C {opin.sym} 35 -190 0 0 {name=p5 lab=VoutN}
C {ipin.sym} -10 -215 0 0 {name=p17 lab=VinP}
C {ipin.sym} -7.5 -187.5 0 0 {name=p18 lab=VinN}
C {ipin.sym} -7.5 -90 0 0 {name=p19 lab=Vdd}
C {ipin.sym} -7.5 -162.5 0 0 {name=p20 lab=VPCas}
C {ipin.sym} -7.5 -135 0 0 {name=p21 lab=VNCas}
C {ipin.sym} -7.5 -112.5 0 0 {name=p60 lab=VNMir}
C {lab_pin.sym} 160 275 2 1 {name=p22 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 160 295 2 1 {name=p23 sig_type=std_logic lab=VinN}
C {cellv9/dac_cell_80ua_v9.sym} 260 325 0 0 {name=x1}
C {lab_pin.sym} 360 295 0 1 {name=p24 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 360 275 0 1 {name=p25 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 160 375 2 1 {name=p26 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 160 355 2 1 {name=p27 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 160 335 2 1 {name=p28 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 160 315 2 1 {name=p29 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 160 420 2 1 {name=p30 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 160 440 2 1 {name=p31 sig_type=std_logic lab=VinN}
C {cellv9/dac_cell_80ua_v9.sym} 260 470 0 0 {name=x3}
C {lab_pin.sym} 360 440 0 1 {name=p33 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 360 420 0 1 {name=p34 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 160 520 2 1 {name=p35 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 160 500 2 1 {name=p36 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 160 480 2 1 {name=p37 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 160 460 2 1 {name=p38 sig_type=std_logic lab=VPCas}
