v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lab_pin.sym} 15 -120 2 1 {name=p32 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 15 -100 2 1 {name=p46 sig_type=std_logic lab=VinN}
C {cellv9/dac_cell_80ua_v9.sym} 115 -70 0 0 {name=x5}
C {lab_pin.sym} 215 -100 0 1 {name=p15 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 215 -120 0 1 {name=p16 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 15 -20 2 1 {name=p1 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 15 -40 2 1 {name=p6 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 15 -60 2 1 {name=p12 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 15 -80 2 1 {name=p3 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 15 25 2 1 {name=p4 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 15 45 2 1 {name=p7 sig_type=std_logic lab=VinN}
C {cellv9/dac_cell_80ua_v9.sym} 115 75 0 0 {name=x2}
C {lab_pin.sym} 215 45 0 1 {name=p8 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 215 25 0 1 {name=p9 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 15 125 2 1 {name=p10 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 15 105 2 1 {name=p11 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 15 85 2 1 {name=p13 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 15 65 2 1 {name=p14 sig_type=std_logic lab=VPCas}
C {opin.sym} -102.5 -320 0 0 {name=p2 lab=VoutP}
C {opin.sym} -100 -295 0 0 {name=p5 lab=VoutN}
C {ipin.sym} -145 -320 0 0 {name=p17 lab=VinP}
C {ipin.sym} -142.5 -292.5 0 0 {name=p18 lab=VinN}
C {ipin.sym} -142.5 -195 0 0 {name=p19 lab=Vdd}
C {ipin.sym} -142.5 -267.5 0 0 {name=p20 lab=VPCas}
C {ipin.sym} -142.5 -240 0 0 {name=p21 lab=VNCas}
C {ipin.sym} -142.5 -217.5 0 0 {name=p60 lab=VNMir}
