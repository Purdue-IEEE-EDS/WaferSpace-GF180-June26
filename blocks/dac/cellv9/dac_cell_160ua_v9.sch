v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lab_pin.sym} 15 -120 2 1 {name=p32 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 15 -100 2 1 {name=p46 sig_type=std_logic lab=VinN}
C {cellv9/dac_cell_80ua_v9.sym} 115 -80 0 0 {name=x1[1:0]}
C {lab_pin.sym} 215 -100 0 1 {name=p15 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 215 -120 0 1 {name=p16 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 15 -40 2 1 {name=p1 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 15 -60 2 1 {name=p6 sig_type=std_logic lab=IREF_10UA[1:0]}
C {lab_pin.sym} 15 -80 2 1 {name=p3 sig_type=std_logic lab=VCAS_IN}
C {opin.sym} -102.5 -320 0 0 {name=p2 lab=VoutP}
C {opin.sym} -100 -295 0 0 {name=p5 lab=VoutN}
C {ipin.sym} -145 -320 0 0 {name=p17 lab=VinP}
C {ipin.sym} -142.5 -292.5 0 0 {name=p18 lab=VinN}
C {ipin.sym} -142.5 -213.75 0 0 {name=p19 lab=Vdd}
C {ipin.sym} -142.5 -267.5 0 0 {name=p20 lab=VCAS_IN}
C {ipin.sym} -142.5 -240 0 0 {name=p21 lab=IREF_10UA[1:0]}
