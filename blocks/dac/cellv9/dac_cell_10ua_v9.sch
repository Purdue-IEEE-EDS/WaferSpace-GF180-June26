v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 1292.5 862.5 1292.5 892.5 {lab=VxP}
N 1362.5 767.5 1437.5 767.5 {lab=#net1}
N 1292.5 767.5 1362.5 767.5 {lab=#net1}
N 1432.5 832.5 1437.5 832.5 {lab=Vdd}
N 1287.5 832.5 1292.5 832.5 {lab=Vdd}
N 1292.5 937.5 1297.5 937.5 {lab=Vdd}
N 1432.5 937.5 1437.5 937.5 {lab=Vdd}
N 1547.5 1030 1552.5 1030 {lab=Vdd}
N 1547.5 1065 1547.5 1080 {lab=#net2}
N 1547.5 1055 1547.5 1065 {lab=#net2}
N 1547.5 985 1547.5 1000 {lab=Vdd}
N 1547.5 1150 1547.5 1165 {lab=0}
N 1432.5 1075 1437.5 1075 {lab=Vdd}
N 1437.5 1030 1437.5 1045 {lab=VoutN}
N 1437.5 995 1437.5 1030 {lab=VoutN}
N 1437.5 1125 1437.5 1140 {lab=VoutN}
N 1487.5 1075 1502.5 1075 {lab=#net2}
N 1437.5 1105 1437.5 1125 {lab=VoutN}
N 1437.5 975 1437.5 995 {lab=VoutN}
N 1502.5 1075 1522.5 1075 {lab=#net2}
N 1477.5 1075 1487.5 1075 {lab=#net2}
N 1547.5 1080 1547.5 1085 {lab=#net2}
N 1522.5 1075 1547.5 1075 {lab=#net2}
N 1547.5 1085 1547.5 1090 {lab=#net2}
N 1177.5 1030 1182.5 1030 {lab=Vdd}
N 1182.5 1065 1182.5 1080 {lab=#net3}
N 1182.5 1055 1182.5 1065 {lab=#net3}
N 1182.5 985 1182.5 1000 {lab=Vdd}
N 1182.5 1150 1182.5 1165 {lab=0}
N 1292.5 1075 1297.5 1075 {lab=Vdd}
N 1292.5 1030 1292.5 1045 {lab=VoutP}
N 1292.5 1125 1292.5 1140 {lab=VoutP}
N 1227.5 1075 1242.5 1075 {lab=#net3}
N 1292.5 1105 1292.5 1125 {lab=VoutP}
N 1292.5 1140 1292.5 1170 {lab=VoutP}
N 1342.5 1035 1342.5 1095 {lab=VoutP}
N 1207.5 1075 1227.5 1075 {lab=#net3}
N 1242.5 1075 1252.5 1075 {lab=#net3}
N 1182.5 1080 1182.5 1085 {lab=#net3}
N 1182.5 1075 1207.5 1075 {lab=#net3}
N 1182.5 1085 1182.5 1090 {lab=#net3}
N 1292.5 1115 1342.5 1115 {lab=VoutP}
N 1292.5 1035 1342.5 1035 {lab=VoutP}
N 1387.5 1115 1437.5 1115 {lab=VoutN}
N 1387.5 1035 1437.5 1035 {lab=VoutN}
N 1387.5 1035 1387.5 1115 {lab=VoutN}
N 1342.5 1095 1342.5 1115 {lab=VoutP}
N 1292.5 1005 1292.5 1030 {lab=VoutP}
N 1292.5 967.5 1292.5 982.5 {lab=VoutP}
N 1820 955 1820 970 {lab=VCB_REF}
N 1437.5 862.5 1437.5 892.5 {lab=VxN}
N 1437.5 967.5 1437.5 972.5 {lab=VoutN}
N 1950 810 1950 875 {lab=VcbP}
N 1830 875 1950 875 {lab=VcbP}
N 1830 800 1830 875 {lab=VcbP}
N 1945 647.5 1945 702.5 {lab=VcbN}
N 1945 702.5 1945 707.5 {lab=VcbN}
N 1825 637.5 1825 702.5 {lab=VcbN}
N 1825 702.5 1825 707.5 {lab=VcbN}
N 1825 707.5 1945 707.5 {lab=VcbN}
N 630 810 635 810 {lab=0}
N 630 650 630 670 {lab=#net4}
N 630 755 630 780 {lab=Vg1P}
N 565 605 590 605 {lab=VinPDr}
N 565 710 590 710 {lab=VinPDr}
N 565 810 590 810 {lab=VinPDr}
N 565 775 565 810 {lab=VinPDr}
N 975 810 1000 810 {lab=VinNDr}
N 1000 775 1000 810 {lab=VinNDr}
N 940 650 940 670 {lab=#net5}
N 840 555 940 555 {lab=VH}
N 980 605 1000 605 {lab=VinNDr}
N 980 710 1000 710 {lab=VinNDr}
N 1000 620 1000 700 {lab=VinNDr}
N 1000 725 1000 775 {lab=VinNDr}
N 940 765 940 780 {lab=Vg1N}
N 705 605 710 605 {lab=Vdd}
N 850 605 860 605 {lab=Vdd}
N 850 810 855 810 {lab=Vdd}
N 735 810 740 810 {lab=Vdd}
N 565 620 565 700 {lab=VinPDr}
N 630 555 680 555 {lab=VH}
N 940 740 940 750 {lab=Vg1N}
N 565 725 565 775 {lab=VinPDr}
N 630 840 630 875 {lab=VL}
N 735 840 735 875 {lab=VL}
N 850 840 850 875 {lab=VL}
N 940 840 940 875 {lab=VL}
N 680 555 765 555 {lab=VH}
N 815 875 940 875 {lab=VL}
N 630 875 760 875 {lab=VL}
N 815 555 840 555 {lab=VH}
N 625 605 630 605 {lab=Vdd}
N 710 635 710 650 {lab=#net4}
N 630 650 710 650 {lab=#net4}
N 630 635 630 650 {lab=#net4}
N 565 605 565 620 {lab=VinPDr}
N 940 635 940 650 {lab=#net5}
N 1000 605 1000 620 {lab=VinNDr}
N 940 605 945 605 {lab=Vdd}
N 855 650 940 650 {lab=#net5}
N 630 740 630 755 {lab=Vg1P}
N 565 710 565 725 {lab=VinPDr}
N 940 750 940 765 {lab=Vg1N}
N 1000 710 1000 725 {lab=VinNDr}
N 630 670 630 680 {lab=#net4}
N 940 670 940 680 {lab=#net5}
N 1000 700 1000 710 {lab=VinNDr}
N 565 700 565 710 {lab=VinPDr}
N 630 740 735 740 {lab=Vg1P}
N 850 740 940 740 {lab=Vg1N}
N 760 875 815 875 {lab=VL}
N 765 555 815 555 {lab=VH}
N 735 740 850 780 {lab=Vg1P}
N 735 780 850 740 {lab=Vg1N}
N 695 810 695 840 {lab=VinPDr}
N 695 840 695 845 {lab=VinPDr}
N 695 845 695 850 {lab=VinPDr}
N 565 850 695 850 {lab=VinPDr}
N 565 810 565 850 {lab=VinPDr}
N 890 810 890 850 {lab=VinNDr}
N 890 850 1000 850 {lab=VinNDr}
N 1000 810 1000 850 {lab=VinNDr}
N 940 555 940 570 {lab=VH}
N 940 570 940 575 {lab=VH}
N 855 555 855 575 {lab=VH}
N 710 555 710 575 {lab=VH}
N 630 555 630 575 {lab=VH}
N 935 810 940 810 {lab=0}
N 940 710 945 710 {lab=Vdd}
N 625 710 630 710 {lab=Vdd}
N 750 605 770 605 {lab=VinNDr}
N 770 605 825 665 {lab=VinNDr}
N 855 635 855 645 {lab=#net5}
N 855 645 855 650 {lab=#net5}
N 795 605 815 605 {lab=VinPDr}
N 745 665 795 605 {lab=VinPDr}
N 1437.5 972.5 1437.5 975 {lab=VoutN}
N 1292.5 982.5 1292.5 1005 {lab=VoutP}
N 1437.5 767.5 1437.5 802.5 {lab=#net1}
N 1437.5 897.5 1437.5 907.5 {lab=VxN}
N 1437.5 892.5 1437.5 897.5 {lab=VxN}
N 1292.5 892.5 1292.5 907.5 {lab=VxP}
N 1292.5 767.5 1292.5 802.5 {lab=#net1}
N 1437.5 1140 1437.5 1165 {lab=VoutN}
N 567.5 665 745 665 {lab=VinPDr}
N 565 665 567.5 665 {lab=VinPDr}
N 825 665 1000 665 {lab=VinNDr}
N 1142.5 1030 1142.5 1117.5 {lab=Vg1P}
N 1587.5 1030 1587.5 1122.5 {lab=Vg1N}
N 1142.5 1117.5 1142.5 1120 {lab=Vg1P}
N 1362.5 532.5 1362.5 567.5 {lab=Vdd}
N 1362.5 627.5 1362.5 647.5 {lab=#net6}
N 397.5 690 405 690 {lab=VinNDr}
N 397.5 600 405 600 {lab=VinPDr}
N 1362.5 765 1362.5 767.5 {lab=#net1}
N 242.5 1020 242.5 1035 {lab=VH}
N 242.5 1207.5 242.5 1222.5 {lab=VL}
N 242.5 1127.5 242.5 1132.5 {lab=FB}
N 242.5 1222.5 242.5 1245 {lab=VL}
N 237.5 970 242.5 970 {lab=Vdd}
N 242.5 1000 242.5 1020 {lab=VH}
N 242.5 1112.5 242.5 1122.5 {lab=FB}
N 202.5 970 202.5 1015 {lab=FB}
N 202.5 1015 202.5 1092.5 {lab=FB}
N 242.5 1100 242.5 1107.5 {lab=FB}
N 202.5 1107.5 202.5 1275 {lab=FB}
N 242.5 1095 242.5 1100 {lab=FB}
N 202.5 970 205 970 {lab=FB}
N 242.5 1122.5 242.5 1127.5 {lab=FB}
N 202.5 1122.5 242.5 1122.5 {lab=FB}
N 507.5 1153.75 537.5 1153.75 {lab=VL}
N 537.5 1153.75 577.5 1153.75 {lab=VL}
N 505 1122.5 527.5 1122.5 {lab=VH}
N 476.25 1062.5 526.25 1062.5 {lab=Vdd}
N 527.5 1122.5 577.5 1122.5 {lab=VH}
N 577.5 1153.75 617.5 1153.75 {lab=VL}
N 202.5 1092.5 202.5 1107.5 {lab=FB}
N 577.5 1122.5 615 1122.5 {lab=VH}
N 526.25 1062.5 571.25 1062.5 {lab=Vdd}
N 242.5 1107.5 242.5 1112.5 {lab=FB}
N 472.5 1153.75 507.5 1153.75 {lab=VL}
N 571.25 1062.5 608.75 1062.5 {lab=Vdd}
N 471.25 1062.5 476.25 1062.5 {lab=Vdd}
N 472.5 1122.5 505 1122.5 {lab=VH}
N 242.5 1222.5 282.5 1222.5 {lab=VL}
N 242.5 922.5 242.5 937.5 {lab=Vdd}
N 242.5 1017.5 282.5 1017.5 {lab=VH}
N 242.5 1132.5 242.5 1147.5 {lab=FB}
N 242.5 937.5 242.5 940 {lab=Vdd}
N 242.5 1147.5 242.5 1150 {lab=FB}
N 505 1213.75 527.5 1213.75 {lab=0}
N 527.5 1213.75 577.5 1213.75 {lab=0}
N 577.5 1213.75 615 1213.75 {lab=0}
N 472.5 1213.75 505 1213.75 {lab=0}
N 615 1213.75 615 1215 {lab=0}
N 472.5 1062.5 472.5 1065 {lab=Vdd}
N 522.5 1062.5 522.5 1065 {lab=Vdd}
N 572.5 1062.5 572.5 1065 {lab=Vdd}
C {param.sym} 560 505 0 0 {name=s8 value="cmLw=0.3u"
}
C {param.sym} 560 485 0 0 {name=s10 value="cmHw=0.3u"
}
C {param.sym} 805 505 0 0 {name=s11 value="cmLfbw=1.0u"
}
C {param.sym} 805 485 0 0 {name=s14 value="cmHfbw=0.22u"
}
C {symbols/pfet_03v3.sym} 1272.5 832.5 0 0 {name=M20
L=0.28u
W=\{cswW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1457.5 832.5 0 1 {name=M21
L=0.28u
W=\{cswW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1292.5 832.5 0 1 {name=p41 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1432.5 832.5 0 0 {name=p47 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1272.5 937.5 0 0 {name=M22
L=0.28u
W=\{cbufW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1297.5 937.5 0 1 {name=p53 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1457.5 937.5 0 1 {name=M23
L=0.28u
W=\{cbufW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1432.5 937.5 0 0 {name=p58 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1567.5 1030 0 1 {name=M24
L=0.28u
W=\{invPw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1547.5 1030 0 0 {name=p63 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1547.5 1120 1 1 {name=l2 lab=0}
C {symbols/nfet_03v3.sym} 1567.5 1120 0 1 {name=M34
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1547.5 1165 0 0 {name=l6 lab=0}
C {symbols/pfet_03v3.sym} 1457.5 1075 0 1 {name=M35
L=0.28u
W=\{dummyW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1432.5 1075 0 0 {name=p68 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1162.5 1030 0 0 {name=M36
L=0.28u
W=\{invPw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1182.5 1030 0 1 {name=p73 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1182.5 1120 3 0 {name=l4 lab=0}
C {symbols/nfet_03v3.sym} 1162.5 1120 0 0 {name=M37
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1182.5 1165 0 1 {name=l5 lab=0}
C {symbols/pfet_03v3.sym} 1272.5 1075 0 0 {name=M38
L=0.28u
W=\{dummyW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1297.5 1075 0 1 {name=p76 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 1182.5 985 0 0 {name=p78 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 1547.5 985 0 0 {name=p79 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1820 1030 0 0 {name=l8 lab=0}
C {vsource.sym} 1820 1000 0 0 {name=VcbRef3 value=\{Vcbias\} savecurrent=true}
C {lab_pin.sym} 1820 955 0 1 {name=p82 sig_type=std_logic lab=VCB_REF}
C {lab_pin.sym} 1477.5 937.5 2 0 {name=p83 sig_type=std_logic lab=VcbN}
C {param.sym} 1815 942.5 0 0 {name=s3 value="VcBias=0.85"
}
C {lab_pin.sym} 1292.5 885 2 1 {name=p87 sig_type=std_logic lab=VxP}
C {lab_pin.sym} 1437.5 885 0 0 {name=p88 sig_type=std_logic lab=VxN}
C {lab_pin.sym} 1830 800 2 1 {name=p89 sig_type=std_logic lab=VcbP}
C {lab_pin.sym} 1950 760 0 1 {name=p90 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1950 780 2 0 {name=p91 sig_type=std_logic lab=VCB_REF}
C {lab_pin.sym} 1252.5 937.5 0 0 {name=p92 sig_type=std_logic lab=VcbP}
C {lab_pin.sym} 1825 637.5 0 0 {name=p93 sig_type=std_logic lab=VcbN}
C {lab_pin.sym} 1945 597.5 2 0 {name=p94 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1945 617.5 0 1 {name=p95 sig_type=std_logic lab=VCB_REF}
C {cellv9/ota5_ab_buf_v1.sym} 1930 930 0 1 {name=x3}
C {cellv9/ota5_ab_buf_v1.sym} 1925 767.5 0 1 {name=x4}
C {symbols/pfet_03v3.sym} 610 605 0 0 {name=M39
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 610 710 0 0 {name=M40
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 610 810 0 0 {name=M41
L=0.28u
W=\{cmLw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 635 810 3 0 {name=l10 lab=0}
C {symbols/pfet_03v3.sym} 730 605 0 1 {name=M42
L=0.28u
W=\{cmHfbW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 960 605 0 1 {name=M43
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 960 710 0 1 {name=M44
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 960 810 0 1 {name=M45
L=0.28u
W=\{cmLw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 935 810 1 1 {name=l12 lab=0}
C {symbols/pfet_03v3.sym} 835 605 0 0 {name=M46
L=0.28u
W=\{cmHfbW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 715 810 0 0 {name=M47
L=0.28u
W=\{cmLfbw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 870 810 0 1 {name=M48
L=0.28u
W=\{cmLfbw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 740 810 0 1 {name=p96 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 855 810 0 0 {name=p97 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 735 740 0 0 {name=p98 sig_type=std_logic lab=Vg1P}
C {lab_wire.sym} 920 740 0 0 {name=p99 sig_type=std_logic lab=Vg1N}
C {lab_wire.sym} 705 605 0 0 {name=p100 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 765 555 0 1 {name=p101 sig_type=std_logic lab=VH}
C {lab_wire.sym} 630 605 0 1 {name=p102 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 855 605 0 1 {name=p103 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 940 605 0 0 {name=p104 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 630 710 0 1 {name=p105 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 940 710 0 0 {name=p106 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1000 640 2 0 {name=p107 sig_type=std_logic lab=VinNDr}
C {lab_pin.sym} 565 642.5 2 1 {name=p109 sig_type=std_logic lab=VinPDr}
C {lab_wire.sym} 785 875 0 1 {name=p110 sig_type=std_logic lab=VL}
C {lab_pin.sym} 1252.5 832.5 2 1 {name=p117 sig_type=std_logic lab=Vg1P}
C {lab_pin.sym} 1477.5 832.5 0 1 {name=p125 sig_type=std_logic lab=Vg1N}
C {lab_pin.sym} 1292.5 1170 2 0 {name=p127 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 1437.5 1165 0 0 {name=p128 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 1142.5 1072.5 2 1 {name=p135 sig_type=std_logic lab=Vg1P}
C {lab_pin.sym} 1587.5 1072.5 0 1 {name=p136 sig_type=std_logic lab=Vg1N}
C {param.sym} 1420 507.5 0 0 {name=s15 value="dummyW=0.3u"
}
C {param.sym} 1420 487.5 0 0 {name=s16 value="invPW=0.5u"
}
C {param.sym} 1190 487.5 0 0 {name=s17 value="cswW=0.6u"
}
C {param.sym} 1190 510 0 0 {name=s18 value="cbufW=0.6u"
}
C {cellv9/clamp.sym} 750 942.5 0 0 {name=x1}
C {lab_wire.sym} 850 932.5 0 1 {name=p4 sig_type=std_logic lab=VH}
C {lab_wire.sym} 850 952.5 0 1 {name=p5 sig_type=std_logic lab=VL}
C {lab_wire.sym} 650 932.5 0 0 {name=p6 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1342.5 597.5 0 0 {name=M11
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1342.5 677.5 0 0 {name=M12
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1362.5 597.5 0 1 {name=p33 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1362.5 677.5 0 1 {name=p34 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1322.5 677.5 2 1 {name=p35 sig_type=std_logic lab=VS_MIR}
C {lab_pin.sym} 1322.5 597.5 2 1 {name=p36 sig_type=std_logic lab=VS_CAS}
C {lab_pin.sym} 1362.5 532.5 2 1 {name=p37 sig_type=std_logic lab=Vdd}
C {param.sym} 1778.75 520 0 0 {name=s1 value="casW=4u"
}
C {param.sym} 1781.25 495 0 0 {name=s2 value="mirW=4u"
}
C {param.sym} 1781.25 472.5 0 0 {name=s4 value="mirL=1u"
}
C {param.sym} 1783.75 542.5 0 0 {name=s6 value="casL=1u"
}
C {opin.sym} 592.5 235 0 0 {name=p2 lab=VoutP}
C {opin.sym} 595 260 0 0 {name=p3 lab=VoutN}
C {ipin.sym} 550 235 0 0 {name=p7 lab=VinP}
C {ipin.sym} 552.5 262.5 0 0 {name=p8 lab=VinN}
C {ipin.sym} 552.5 330 0 0 {name=p9 lab=Vdd}
C {ipin.sym} 552.5 287.5 0 0 {name=p10 lab=VCAS_IN}
C {ipin.sym} 552.5 307.5 0 0 {name=p60 lab=IREF_10UA}
C {ammeter.sym} 307.5 690 3 0 {name=VinN savecurrent=true spice_ignore=0}
C {common/cmos_buf.sym} 217.5 700 0 0 {name=x5}
C {lab_pin.sym} 177.5 680 2 1 {name=p12 sig_type=std_logic lab=VinN}
C {lab_pin.sym} 177.5 700 2 1 {name=p13 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 405 690 0 1 {name=p19 sig_type=std_logic lab=VinNDr}
C {ammeter.sym} 307.5 600 3 0 {name=VinP savecurrent=true spice_ignore=0}
C {common/cmos_buf.sym} 217.5 610 0 0 {name=x2}
C {lab_pin.sym} 177.5 590 2 1 {name=p20 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 177.5 610 2 1 {name=p21 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 405 600 0 1 {name=p22 sig_type=std_logic lab=VinPDr}
C {lab_pin.sym} 1945 577.5 2 0 {name=p1 sig_type=std_logic lab=VB_10UA}
C {lab_pin.sym} 1950 740 0 1 {name=p14 sig_type=std_logic lab=VB_10UA}
C {symbols/ppolyf_u_1k.sym} 367.5 600 3 0 {name=R3
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 367.5 690 1 0 {name=R1
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 367.5 620 2 0 {name=p15 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 367.5 670 0 0 {name=p16 sig_type=std_logic lab=Vdd}
C {param.sym} 2192.5 503.75 0 0 {name=s5 value="casW=4u"
}
C {param.sym} 2195 478.75 0 0 {name=s7 value="mirW=4u"
}
C {param.sym} 2195 456.25 0 0 {name=s9 value="mirL=1u"
}
C {param.sym} 2197.5 526.25 0 0 {name=s12 value="casL=1u"
}
C {cellv9/cell_iref.sym} 2328.75 587.5 0 0 {name=x6}
C {lab_pin.sym} 2228.75 607.5 0 0 {name=p11 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2428.75 607.5 2 0 {name=p17 sig_type=std_logic lab=VB_10UA}
C {lab_pin.sym} 2228.75 587.5 0 0 {name=p18 sig_type=std_logic lab=IREF_10UA}
C {lab_pin.sym} 2228.75 567.5 0 0 {name=p29 sig_type=std_logic lab=VCAS_IN}
C {lab_pin.sym} 2428.75 567.5 2 0 {name=p54 sig_type=std_logic lab=VS_CAS}
C {lab_pin.sym} 2428.75 587.5 2 0 {name=p55 sig_type=std_logic lab=VS_MIR}
C {ammeter.sym} 1362.5 737.5 0 0 {name=Vcx savecurrent=true spice_ignore=0}
C {gnd.sym} 242.5 1275 3 0 {name=l13 lab=0}
C {symbols/nfet_03v3.sym} 222.5 1275 0 0 {name=M49
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 222.5 970 0 0 {name=M50
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 242.5 970 0 1 {name=p111 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 282.5 1222.5 0 1 {name=p112 sig_type=std_logic lab=VL}
C {lab_pin.sym} 615 1122.5 0 1 {name=p23 sig_type=std_logic lab=VH}
C {lab_pin.sym} 202.5 1122.5 2 1 {name=p115 sig_type=std_logic lab=FB}
C {lab_pin.sym} 617.5 1153.75 0 1 {name=p24 sig_type=std_logic lab=VL}
C {lab_pin.sym} 608.75 1062.5 0 1 {name=p25 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 282.5 1017.5 0 1 {name=p26 sig_type=std_logic lab=VH}
C {lab_pin.sym} 242.5 922.5 0 1 {name=p27 sig_type=std_logic lab=Vdd}
C {gnd.sym} 242.5 1305 0 0 {name=Data9 lab=0
value="PULSE(3.3 0 \{clk*0.5\} 30ps 30ps \{clk*1\} \{clk*2\})"
}
C {symbols/ppolyf_u_1k.sym} 242.5 1180 0 0 {name=R2
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 242.5 1065 0 0 {name=R4
W=1e-6
L=20e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 222.5 1065 0 0 {name=p28 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 222.5 1180 0 0 {name=p30 sig_type=std_logic lab=Vdd}
C {symbols/cap_mim_analog.sym} 472.5 1092.5 0 0 {name=C2
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1
C=1pF}
C {symbols/cap_mim_analog.sym} 522.5 1092.5 0 0 {name=C1
W=10e-6
L=5e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1
C=100fF}
C {symbols/cap_mim_analog.sym} 572.5 1092.5 0 0 {name=C3
W=5e-6
L=5e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1
C=50fF}
C {symbols/cap_mim_analog.sym} 472.5 1183.75 0 0 {name=C4
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1
C=1pF}
C {symbols/cap_mim_analog.sym} 522.5 1183.75 0 0 {name=C5
W=10e-6
L=5e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1
C=100fF}
C {symbols/cap_mim_analog.sym} 572.5 1183.75 0 0 {name=C6
W=5e-6
L=5e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1
C=50fF}
C {gnd.sym} 615 1213.75 0 0 {name=Data1 lab=0
value="PULSE(3.3 0 \{clk*0.5\} 30ps 30ps \{clk*1\} \{clk*2\})"
}
C {lab_pin.sym} -22.5 952.5 0 1 {name=p31 sig_type=std_logic lab=Vdd}
C {symbols/cap_mim_analog.sym} -22.5 982.5 0 0 {name=C7
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1
C=1pF}
C {gnd.sym} -22.5 1012.5 0 0 {name=Data2 lab=0
value="PULSE(3.3 0 \{clk*0.5\} 30ps 30ps \{clk*1\} \{clk*2\})"
}
C {lab_pin.sym} -21.25 1100 0 1 {name=p32 sig_type=std_logic lab=FB}
C {symbols/cap_mim_analog.sym} -21.25 1130 0 0 {name=C8
W=10e-6
L=5e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=8
C=1pF}
C {gnd.sym} -21.25 1160 0 0 {name=Data3 lab=0
value="PULSE(3.3 0 \{clk*0.5\} 30ps 30ps \{clk*1\} \{clk*2\})"
}
