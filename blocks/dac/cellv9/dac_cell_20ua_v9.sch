v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {10uA local mirror} 2020 778.75 0 0 0.25 0.25 {}
T {10uA} 2487.5 822.5 0 0 0.25 0.25 {}
N 1277.5 930 1277.5 960 {lab=VxP}
N 1347.5 835 1422.5 835 {lab=Vcx}
N 1277.5 835 1347.5 835 {lab=Vcx}
N 1417.5 900 1422.5 900 {lab=Vdd}
N 1272.5 900 1277.5 900 {lab=Vdd}
N 1277.5 1005 1282.5 1005 {lab=Vdd}
N 1417.5 1005 1422.5 1005 {lab=Vdd}
N 1532.5 1097.5 1537.5 1097.5 {lab=Vdd}
N 1532.5 1132.5 1532.5 1147.5 {lab=#net1}
N 1532.5 1122.5 1532.5 1132.5 {lab=#net1}
N 1532.5 1052.5 1532.5 1067.5 {lab=Vdd}
N 1532.5 1217.5 1532.5 1232.5 {lab=0}
N 1417.5 1142.5 1422.5 1142.5 {lab=Vdd}
N 1422.5 1097.5 1422.5 1112.5 {lab=VoutN}
N 1422.5 1062.5 1422.5 1097.5 {lab=VoutN}
N 1422.5 1192.5 1422.5 1207.5 {lab=VoutN}
N 1472.5 1142.5 1487.5 1142.5 {lab=#net1}
N 1422.5 1172.5 1422.5 1192.5 {lab=VoutN}
N 1422.5 1042.5 1422.5 1062.5 {lab=VoutN}
N 1487.5 1142.5 1507.5 1142.5 {lab=#net1}
N 1462.5 1142.5 1472.5 1142.5 {lab=#net1}
N 1532.5 1147.5 1532.5 1152.5 {lab=#net1}
N 1507.5 1142.5 1532.5 1142.5 {lab=#net1}
N 1532.5 1152.5 1532.5 1157.5 {lab=#net1}
N 1162.5 1097.5 1167.5 1097.5 {lab=Vdd}
N 1167.5 1132.5 1167.5 1147.5 {lab=#net2}
N 1167.5 1122.5 1167.5 1132.5 {lab=#net2}
N 1167.5 1052.5 1167.5 1067.5 {lab=Vdd}
N 1167.5 1217.5 1167.5 1232.5 {lab=0}
N 1277.5 1142.5 1282.5 1142.5 {lab=Vdd}
N 1277.5 1097.5 1277.5 1112.5 {lab=VoutP}
N 1277.5 1192.5 1277.5 1207.5 {lab=VoutP}
N 1212.5 1142.5 1227.5 1142.5 {lab=#net2}
N 1277.5 1172.5 1277.5 1192.5 {lab=VoutP}
N 1277.5 1207.5 1277.5 1237.5 {lab=VoutP}
N 1327.5 1102.5 1327.5 1162.5 {lab=VoutP}
N 1192.5 1142.5 1212.5 1142.5 {lab=#net2}
N 1227.5 1142.5 1237.5 1142.5 {lab=#net2}
N 1167.5 1147.5 1167.5 1152.5 {lab=#net2}
N 1167.5 1142.5 1192.5 1142.5 {lab=#net2}
N 1167.5 1152.5 1167.5 1157.5 {lab=#net2}
N 1277.5 1182.5 1327.5 1182.5 {lab=VoutP}
N 1277.5 1102.5 1327.5 1102.5 {lab=VoutP}
N 1372.5 1182.5 1422.5 1182.5 {lab=VoutN}
N 1372.5 1102.5 1422.5 1102.5 {lab=VoutN}
N 1372.5 1102.5 1372.5 1182.5 {lab=VoutN}
N 1327.5 1162.5 1327.5 1182.5 {lab=VoutP}
N 1277.5 1072.5 1277.5 1097.5 {lab=VoutP}
N 1277.5 1035 1277.5 1050 {lab=VoutP}
N 1738.75 1131.25 1738.75 1146.25 {lab=VcbRef}
N 1422.5 930 1422.5 960 {lab=VxN}
N 1422.5 1035 1422.5 1040 {lab=VoutN}
N 1738.75 986.25 1738.75 1051.25 {lab=VcbP}
N 1738.75 1051.25 1858.75 1051.25 {lab=VcbP}
N 1858.75 976.25 1858.75 1051.25 {lab=VcbP}
N 1863.75 823.75 1863.75 878.75 {lab=VcbN}
N 1863.75 878.75 1863.75 883.75 {lab=VcbN}
N 1743.75 813.75 1743.75 878.75 {lab=VcbN}
N 1743.75 878.75 1743.75 883.75 {lab=VcbN}
N 1743.75 883.75 1863.75 883.75 {lab=VcbN}
N 630 810 635 810 {lab=0}
N 630 650 630 670 {lab=#net3}
N 630 755 630 780 {lab=Vg1P}
N 565 605 590 605 {lab=VinPDr}
N 565 710 590 710 {lab=VinPDr}
N 565 810 590 810 {lab=VinPDr}
N 565 775 565 810 {lab=VinPDr}
N 975 810 1000 810 {lab=VinNDr}
N 1000 775 1000 810 {lab=VinNDr}
N 940 650 940 670 {lab=#net4}
N 840 555 940 555 {lab=VH}
N 980 605 1000 605 {lab=VinNDr}
N 980 710 1000 710 {lab=VinNDr}
N 1000 620 1000 700 {lab=VinNDr}
N 1000 725 1000 775 {lab=VinNDr}
N 940 765 940 780 {lab=Vg1N}
N 705 605 710 605 {lab=Vdd}
N 850 605 860 605 {lab=Vdd}
N 850 810 855 810 {lab=Vdd}
N 735 810 740 810 {lab=Vdd}
N 565 620 565 700 {lab=VinPDr}
N 630 555 680 555 {lab=VH}
N 940 740 940 750 {lab=Vg1N}
N 565 725 565 775 {lab=VinPDr}
N 630 840 630 875 {lab=VL}
N 735 840 735 875 {lab=VL}
N 850 840 850 875 {lab=VL}
N 940 840 940 875 {lab=VL}
N 680 555 765 555 {lab=VH}
N 815 875 940 875 {lab=VL}
N 630 875 760 875 {lab=VL}
N 815 555 840 555 {lab=VH}
N 625 605 630 605 {lab=Vdd}
N 710 635 710 650 {lab=#net3}
N 630 650 710 650 {lab=#net3}
N 630 635 630 650 {lab=#net3}
N 565 605 565 620 {lab=VinPDr}
N 940 635 940 650 {lab=#net4}
N 1000 605 1000 620 {lab=VinNDr}
N 940 605 945 605 {lab=Vdd}
N 855 650 940 650 {lab=#net4}
N 630 740 630 755 {lab=Vg1P}
N 565 710 565 725 {lab=VinPDr}
N 940 750 940 765 {lab=Vg1N}
N 1000 710 1000 725 {lab=VinNDr}
N 630 670 630 680 {lab=#net3}
N 940 670 940 680 {lab=#net4}
N 1000 700 1000 710 {lab=VinNDr}
N 565 700 565 710 {lab=VinPDr}
N 630 740 735 740 {lab=Vg1P}
N 850 740 940 740 {lab=Vg1N}
N 760 875 815 875 {lab=VL}
N 765 555 815 555 {lab=VH}
N 735 740 850 780 {lab=Vg1P}
N 735 780 850 740 {lab=Vg1N}
N 695 810 695 840 {lab=VinPDr}
N 695 840 695 845 {lab=VinPDr}
N 695 845 695 850 {lab=VinPDr}
N 565 850 695 850 {lab=VinPDr}
N 565 810 565 850 {lab=VinPDr}
N 890 810 890 850 {lab=VinNDr}
N 890 850 1000 850 {lab=VinNDr}
N 1000 810 1000 850 {lab=VinNDr}
N 940 555 940 570 {lab=VH}
N 940 570 940 575 {lab=VH}
N 855 555 855 575 {lab=VH}
N 710 555 710 575 {lab=VH}
N 630 555 630 575 {lab=VH}
N 935 810 940 810 {lab=0}
N 940 710 945 710 {lab=Vdd}
N 625 710 630 710 {lab=Vdd}
N 750 605 770 605 {lab=VinNDr}
N 770 605 825 665 {lab=VinNDr}
N 855 635 855 645 {lab=#net4}
N 855 645 855 650 {lab=#net4}
N 795 605 815 605 {lab=VinPDr}
N 745 665 795 605 {lab=VinPDr}
N 1422.5 1040 1422.5 1042.5 {lab=VoutN}
N 1277.5 1050 1277.5 1072.5 {lab=VoutP}
N 1422.5 835 1422.5 870 {lab=Vcx}
N 1422.5 965 1422.5 975 {lab=VxN}
N 1422.5 960 1422.5 965 {lab=VxN}
N 1277.5 960 1277.5 975 {lab=VxP}
N 1277.5 835 1277.5 870 {lab=Vcx}
N 1422.5 1207.5 1422.5 1232.5 {lab=VoutN}
N 567.5 665 745 665 {lab=VinPDr}
N 565 665 567.5 665 {lab=VinPDr}
N 825 665 1000 665 {lab=VinNDr}
N 1127.5 1097.5 1127.5 1185 {lab=Vg1P}
N 1572.5 1097.5 1572.5 1190 {lab=Vg1N}
N 1127.5 1185 1127.5 1187.5 {lab=Vg1P}
N 1276.25 783.75 1416.25 783.75 {lab=Vcx}
N 1276.25 548.75 1276.25 583.75 {lab=Vdd}
N 1276.25 643.75 1276.25 663.75 {lab=#net5}
N 1276.25 723.75 1276.25 783.75 {lab=Vcx}
N 1416.25 548.75 1416.25 583.75 {lab=Vdd}
N 1416.25 643.75 1416.25 663.75 {lab=#net6}
N 1416.25 723.75 1416.25 783.75 {lab=Vcx}
N 1347.5 783.75 1347.5 815 {lab=Vcx}
N 1347.5 815 1347.5 835 {lab=Vcx}
N 382.5 790 390 790 {lab=VinNDr}
N 382.5 700 390 700 {lab=VinPDr}
N 2156.25 872.5 2156.25 897.5 {lab=#net7}
N 2196.25 722.5 2256.25 722.5 {lab=VPMir}
N 2156.25 752.5 2156.25 762.5 {lab=VPMir}
N 2196.25 722.5 2196.25 762.5 {lab=VPMir}
N 2156.25 957.5 2156.25 987.5 {lab=0}
N 2156.25 762.5 2156.25 812.5 {lab=VPMir}
N 2196.25 637.5 2256.25 637.5 {lab=VPCas}
N 2156.25 667.5 2156.25 692.5 {lab=#net8}
N 2156.25 762.5 2196.25 762.5 {lab=VPMir}
N 2156.25 582.5 2156.25 608.75 {lab=Vdd}
N 2352.5 792.5 2352.5 812.5 {lab=#net9}
N 2352.5 872.5 2352.5 897.5 {lab=#net10}
N 2352.5 957.5 2352.5 987.5 {lab=0}
N 2352.5 717.5 2352.5 732.5 {lab=Vdd}
N 2392.5 762.5 2392.5 792.5 {lab=#net9}
N 2352.5 792.5 2392.5 792.5 {lab=#net9}
N 2390 762.5 2392.5 762.5 {lab=#net9}
N 2477.5 717.5 2477.5 732.5 {lab=Vdd}
N 2477.5 860 2517.5 860 {lab=IB10}
N 2477.5 860 2477.5 861.25 {lab=IB10}
N 2477.5 791.25 2477.5 860 {lab=IB10}
N 2515 890 2517.5 890 {lab=IB10}
N 2352.5 762.5 2356.25 762.5 {lab=Vdd}
N 2473.75 762.5 2477.5 762.5 {lab=Vdd}
N 2476.25 890 2481.25 890 {lab=0}
N 2517.5 860 2517.5 890 {lab=IB10}
N 2517.5 890 2542.5 890 {lab=IB10}
N 2392.5 842.5 2392.5 873.75 {lab=VNMir}
N 2392.5 873.75 2392.5 881.25 {lab=VNMir}
N 2196.25 842.5 2196.25 881.25 {lab=VNMir}
N 2392.5 927.5 2392.5 965 {lab=VNCas}
N 2196.25 927.5 2196.25 965 {lab=VNCas}
N 2477.5 920 2477.5 951.25 {lab=0}
N 2477.5 951.25 2477.5 952.5 {lab=0}
N 2392.5 762.5 2437.5 762.5 {lab=#net9}
N 2351.25 717.5 2477.5 717.5 {lab=Vdd}
N 2196.25 881.25 2392.5 881.25 {lab=VNMir}
N 2196.25 965 2392.5 965 {lab=VNCas}
C {param.sym} 592.5 505 0 0 {name=s8 value="cmLw=0.4u"
}
C {param.sym} 592.5 485 0 0 {name=s10 value="cmHw=0.5u"
}
C {param.sym} 822.5 505 0 0 {name=s11 value="cmLfbw=1.8u"
}
C {param.sym} 822.5 485 0 0 {name=s14 value="cmHfbw=0.22u"
}
C {symbols/pfet_03v3.sym} 1257.5 900 0 0 {name=M20
L=0.28u
W=\{cswW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1442.5 900 0 1 {name=M21
L=0.28u
W=\{cswW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1277.5 900 0 1 {name=p41 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1417.5 900 0 0 {name=p47 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1257.5 1005 0 0 {name=M22
L=0.28u
W=\{cbufW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1282.5 1005 0 1 {name=p53 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1442.5 1005 0 1 {name=M23
L=0.28u
W=\{cbufW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1417.5 1005 0 0 {name=p58 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1552.5 1097.5 0 1 {name=M24
L=0.28u
W=\{invPw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1532.5 1097.5 0 0 {name=p63 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1532.5 1187.5 1 1 {name=l2 lab=0}
C {symbols/nfet_03v3.sym} 1552.5 1187.5 0 1 {name=M34
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1532.5 1232.5 0 0 {name=l6 lab=0}
C {symbols/pfet_03v3.sym} 1442.5 1142.5 0 1 {name=M35
L=0.28u
W=\{dummyW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1417.5 1142.5 0 0 {name=p68 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1147.5 1097.5 0 0 {name=M36
L=0.28u
W=\{invPw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1167.5 1097.5 0 1 {name=p73 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1167.5 1187.5 3 0 {name=l4 lab=0}
C {symbols/nfet_03v3.sym} 1147.5 1187.5 0 0 {name=M37
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1167.5 1232.5 0 1 {name=l5 lab=0}
C {symbols/pfet_03v3.sym} 1257.5 1142.5 0 0 {name=M38
L=0.28u
W=\{dummyW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1282.5 1142.5 0 1 {name=p76 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 1167.5 1052.5 0 0 {name=p78 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 1532.5 1052.5 0 0 {name=p79 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1738.75 1206.25 0 0 {name=l8 lab=0}
C {vsource.sym} 1738.75 1176.25 0 0 {name=VcbRef3 value=\{Vcbias\} savecurrent=true}
C {lab_pin.sym} 1738.75 1131.25 0 1 {name=p82 sig_type=std_logic lab=VcbRef}
C {lab_pin.sym} 1462.5 1005 2 0 {name=p83 sig_type=std_logic lab=VcbN}
C {param.sym} 1733.75 1118.75 0 0 {name=s3 value="VcBias=0.78"
}
C {lab_pin.sym} 1347.5 810 2 1 {name=p86 sig_type=std_logic lab=Vcx}
C {lab_pin.sym} 1277.5 952.5 2 1 {name=p87 sig_type=std_logic lab=VxP}
C {lab_pin.sym} 1422.5 952.5 0 0 {name=p88 sig_type=std_logic lab=VxN}
C {lab_pin.sym} 1858.75 976.25 2 0 {name=p89 sig_type=std_logic lab=VcbP}
C {lab_pin.sym} 1738.75 936.25 0 0 {name=p90 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1738.75 956.25 2 1 {name=p91 sig_type=std_logic lab=VcbRef}
C {lab_pin.sym} 1237.5 1005 0 0 {name=p92 sig_type=std_logic lab=VcbP}
C {lab_pin.sym} 1743.75 813.75 0 0 {name=p93 sig_type=std_logic lab=VcbN}
C {lab_pin.sym} 1863.75 773.75 2 0 {name=p94 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1863.75 793.75 0 1 {name=p95 sig_type=std_logic lab=VcbRef}
C {cellv9/ota5_ab_buf_v1.sym} 1758.75 1106.25 0 0 {name=x3}
C {cellv9/ota5_ab_buf_v1.sym} 1843.75 943.75 0 1 {name=x4}
C {symbols/pfet_03v3.sym} 610 605 0 0 {name=M39
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 610 710 0 0 {name=M40
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 610 810 0 0 {name=M41
L=0.28u
W=\{cmLw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 635 810 3 0 {name=l10 lab=0}
C {symbols/pfet_03v3.sym} 730 605 0 1 {name=M42
L=0.28u
W=\{cmHfbW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 960 605 0 1 {name=M43
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 960 710 0 1 {name=M44
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 960 810 0 1 {name=M45
L=0.28u
W=\{cmLw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 935 810 1 1 {name=l12 lab=0}
C {symbols/pfet_03v3.sym} 835 605 0 0 {name=M46
L=0.28u
W=\{cmHfbW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 715 810 0 0 {name=M47
L=0.28u
W=\{cmLfbw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 870 810 0 1 {name=M48
L=0.28u
W=\{cmLfbw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 740 810 0 1 {name=p96 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 855 810 0 0 {name=p97 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 735 740 0 0 {name=p98 sig_type=std_logic lab=Vg1P}
C {lab_wire.sym} 920 740 0 0 {name=p99 sig_type=std_logic lab=Vg1N}
C {lab_wire.sym} 705 605 0 0 {name=p100 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 765 555 0 1 {name=p101 sig_type=std_logic lab=VH}
C {lab_wire.sym} 630 605 0 1 {name=p102 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 855 605 0 1 {name=p103 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 940 605 0 0 {name=p104 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 630 710 0 1 {name=p105 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 940 710 0 0 {name=p106 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1000 640 2 0 {name=p107 sig_type=std_logic lab=VinNDr}
C {lab_pin.sym} 565 642.5 2 1 {name=p109 sig_type=std_logic lab=VinPDr}
C {lab_wire.sym} 785 875 0 1 {name=p110 sig_type=std_logic lab=VL}
C {lab_pin.sym} 1237.5 900 2 1 {name=p117 sig_type=std_logic lab=Vg1P}
C {lab_pin.sym} 1462.5 900 0 1 {name=p125 sig_type=std_logic lab=Vg1N}
C {lab_pin.sym} 1277.5 1237.5 2 0 {name=p127 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 1422.5 1232.5 0 0 {name=p128 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 1127.5 1140 2 1 {name=p135 sig_type=std_logic lab=Vg1P}
C {lab_pin.sym} 1572.5 1140 0 1 {name=p136 sig_type=std_logic lab=Vg1N}
C {param.sym} 1490 510 0 0 {name=s15 value="dummyW=0.4u"
}
C {param.sym} 1490 485 0 0 {name=s16 value="invPW=0.6u"
}
C {param.sym} 1230 490 0 0 {name=s17 value="cswW=2.0u"
}
C {param.sym} 1230 510 0 0 {name=s18 value="cbufW=1.8u"
}
C {cellv9/clamp.sym} 685 927.5 0 0 {name=x1}
C {lab_wire.sym} 785 917.5 0 1 {name=p4 sig_type=std_logic lab=VH}
C {lab_wire.sym} 785 937.5 0 1 {name=p5 sig_type=std_logic lab=VL}
C {lab_wire.sym} 585 917.5 0 0 {name=p6 sig_type=std_logic lab=Vdd}
C {opin.sym} 612.5 296.25 0 0 {name=p80 lab=VoutP}
C {opin.sym} 615 321.25 0 0 {name=p81 lab=VoutN}
C {ipin.sym} 570 296.25 0 0 {name=p84 lab=VinP}
C {ipin.sym} 572.5 323.75 0 0 {name=p85 lab=VinN}
C {ipin.sym} 572.5 421.25 0 0 {name=p129 lab=Vdd}
C {ipin.sym} 572.5 348.75 0 0 {name=p130 lab=VPCas}
C {ipin.sym} 572.5 376.25 0 0 {name=p131 lab=VNCas}
C {ipin.sym} 572.5 398.75 0 0 {name=p60 lab=VNMir}
C {symbols/pfet_03v3.sym} 1256.25 613.75 0 0 {name=M9
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1256.25 693.75 0 0 {name=M10
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1276.25 613.75 0 1 {name=p28 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1276.25 693.75 0 1 {name=p29 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1276.25 548.75 2 1 {name=p32 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1396.25 613.75 0 0 {name=M11
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1396.25 693.75 0 0 {name=M12
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1416.25 613.75 0 1 {name=p33 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1416.25 693.75 0 1 {name=p34 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1376.25 693.75 2 1 {name=p35 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1376.25 613.75 2 1 {name=p36 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1416.25 548.75 2 1 {name=p37 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1236.25 613.75 2 1 {name=p2 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1236.25 693.75 2 1 {name=p3 sig_type=std_logic lab=VPMir}
C {ammeter.sym} 292.5 790 3 0 {name=VinN savecurrent=true spice_ignore=0}
C {common/cmos_buf.sym} 202.5 800 0 0 {name=x5}
C {lab_pin.sym} 162.5 780 2 1 {name=p7 sig_type=std_logic lab=VinN}
C {lab_pin.sym} 162.5 800 2 1 {name=p8 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 390 790 0 1 {name=p9 sig_type=std_logic lab=VinNDr}
C {ammeter.sym} 292.5 700 3 0 {name=VinP savecurrent=true spice_ignore=0}
C {common/cmos_buf.sym} 202.5 710 0 0 {name=x2}
C {lab_pin.sym} 162.5 690 2 1 {name=p10 sig_type=std_logic lab=VinP}
C {lab_pin.sym} 162.5 710 2 1 {name=p11 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 390 700 0 1 {name=p12 sig_type=std_logic lab=VinPDr}
C {lab_pin.sym} 1863.75 753.75 2 0 {name=p20 sig_type=std_logic lab=IB10}
C {lab_pin.sym} 1738.75 916.25 0 0 {name=p21 sig_type=std_logic lab=IB10}
C {symbols/ppolyf_u_1k.sym} 352.5 700 3 0 {name=R3
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 352.5 770 0 0 {name=p23 sig_type=std_logic lab=Vdd}
C {symbols/ppolyf_u_1k.sym} 352.5 790 1 0 {name=R1
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 352.5 720 2 0 {name=p24 sig_type=std_logic lab=Vdd}
C {param.sym} 2110 492.5 0 0 {name=s6 value="casW=4u"
}
C {param.sym} 2112.5 467.5 0 0 {name=s7 value="mirW=4u"
}
C {param.sym} 2112.5 445 0 0 {name=s9 value="mirL=1u"
}
C {param.sym} 2115 515 0 0 {name=s12 value="casL=1u"
}
C {gnd.sym} 2156.25 842.5 1 1 {name=l17 lab=0}
C {symbols/nfet_03v3.sym} 2176.25 842.5 0 1 {name=M1
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2176.25 722.5 0 1 {name=M4
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2156.25 722.5 0 0 {name=p22 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2156.25 927.5 1 1 {name=l18 lab=0}
C {symbols/nfet_03v3.sym} 2176.25 927.5 0 1 {name=M5
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2156.25 987.5 0 1 {name=l19 lab=0}
C {symbols/pfet_03v3.sym} 2176.25 637.5 0 1 {name=M6
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2156.25 637.5 0 0 {name=p25 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2221.25 782.5 0 1 {name=l20 lab=0}
C {lab_pin.sym} 2156.25 582.5 1 0 {name=p26 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2196.25 927.5 0 1 {name=p27 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 2196.25 842.5 0 1 {name=p30 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 2255 722.5 2 0 {name=p31 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 2256.25 637.5 2 0 {name=p38 sig_type=std_logic lab=VPCas}
C {gnd.sym} 2352.5 842.5 1 1 {name=l21 lab=0}
C {symbols/nfet_03v3.sym} 2372.5 842.5 0 1 {name=M7
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2352.5 927.5 1 1 {name=l22 lab=0}
C {symbols/nfet_03v3.sym} 2372.5 927.5 0 1 {name=M8
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2352.5 987.5 0 1 {name=l24 lab=0}
C {lab_pin.sym} 2392.5 927.5 0 1 {name=p39 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 2392.5 842.5 0 1 {name=p40 sig_type=std_logic lab=VNMir}
C {symbols/pfet_03v3.sym} 2372.5 762.5 0 1 {name=M13
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2352.5 717.5 1 0 {name=p42 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 2457.5 762.5 0 0 {name=M14
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2497.5 890 0 1 {name=M15
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2477.5 952.5 0 1 {name=l25 lab=0}
C {lab_pin.sym} 2542.5 890 2 0 {name=p43 sig_type=std_logic lab=IB10}
C {lab_pin.sym} 2352.5 762.5 0 0 {name=p44 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2476.25 762.5 2 0 {name=p45 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2476.25 890 1 1 {name=l26 lab=0}
C {gnd.sym} 2531.25 950 0 1 {name=l27 lab=0}
C {symbols/cap_mim_analog.sym} 2221.25 752.5 0 0 {name=C4
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1}
C {symbols/cap_mim_analog.sym} 2531.25 920 0 0 {name=C3
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1}
