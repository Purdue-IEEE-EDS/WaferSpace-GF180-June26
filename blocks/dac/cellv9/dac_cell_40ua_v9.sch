v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {10uA local mirror} 1856.25 868.75 0 0 0.25 0.25 {}
T {10uA} 2323.75 912.5 0 0 0.25 0.25 {}
N 1275 990 1275 1020 {lab=VxP}
N 1345 895 1420 895 {lab=#net1}
N 1275 895 1345 895 {lab=#net1}
N 1415 960 1420 960 {lab=Vdd}
N 1270 960 1275 960 {lab=Vdd}
N 1275 1065 1280 1065 {lab=Vdd}
N 1415 1065 1420 1065 {lab=Vdd}
N 1530 1157.5 1535 1157.5 {lab=Vdd}
N 1530 1192.5 1530 1207.5 {lab=#net2}
N 1530 1182.5 1530 1192.5 {lab=#net2}
N 1530 1112.5 1530 1127.5 {lab=Vdd}
N 1530 1277.5 1530 1292.5 {lab=0}
N 1415 1202.5 1420 1202.5 {lab=Vdd}
N 1420 1157.5 1420 1172.5 {lab=VoutN}
N 1420 1122.5 1420 1157.5 {lab=VoutN}
N 1420 1252.5 1420 1267.5 {lab=VoutN}
N 1470 1202.5 1485 1202.5 {lab=#net2}
N 1420 1232.5 1420 1252.5 {lab=VoutN}
N 1420 1102.5 1420 1122.5 {lab=VoutN}
N 1485 1202.5 1505 1202.5 {lab=#net2}
N 1460 1202.5 1470 1202.5 {lab=#net2}
N 1530 1207.5 1530 1212.5 {lab=#net2}
N 1505 1202.5 1530 1202.5 {lab=#net2}
N 1530 1212.5 1530 1217.5 {lab=#net2}
N 1160 1157.5 1165 1157.5 {lab=Vdd}
N 1165 1192.5 1165 1207.5 {lab=#net3}
N 1165 1182.5 1165 1192.5 {lab=#net3}
N 1165 1112.5 1165 1127.5 {lab=Vdd}
N 1165 1277.5 1165 1292.5 {lab=0}
N 1275 1202.5 1280 1202.5 {lab=Vdd}
N 1275 1157.5 1275 1172.5 {lab=VoutP}
N 1275 1252.5 1275 1267.5 {lab=VoutP}
N 1210 1202.5 1225 1202.5 {lab=#net3}
N 1275 1232.5 1275 1252.5 {lab=VoutP}
N 1275 1267.5 1275 1297.5 {lab=VoutP}
N 1325 1162.5 1325 1222.5 {lab=VoutP}
N 1190 1202.5 1210 1202.5 {lab=#net3}
N 1225 1202.5 1235 1202.5 {lab=#net3}
N 1165 1207.5 1165 1212.5 {lab=#net3}
N 1165 1202.5 1190 1202.5 {lab=#net3}
N 1165 1212.5 1165 1217.5 {lab=#net3}
N 1275 1242.5 1325 1242.5 {lab=VoutP}
N 1275 1162.5 1325 1162.5 {lab=VoutP}
N 1370 1242.5 1420 1242.5 {lab=VoutN}
N 1370 1162.5 1420 1162.5 {lab=VoutN}
N 1370 1162.5 1370 1242.5 {lab=VoutN}
N 1325 1222.5 1325 1242.5 {lab=VoutP}
N 1275 1132.5 1275 1157.5 {lab=VoutP}
N 1275 1095 1275 1110 {lab=VoutP}
N 910 1110 910 1125 {lab=VcbRef}
N 1420 990 1420 1020 {lab=VxN}
N 1420 1095 1420 1100 {lab=VoutN}
N 965 970 965 1035 {lab=VcbP}
N 965 1035 1085 1035 {lab=VcbP}
N 1085 960 1085 1035 {lab=VcbP}
N 1730 967.5 1730 1022.5 {lab=VcbN}
N 1730 1022.5 1730 1027.5 {lab=VcbN}
N 1610 957.5 1610 1022.5 {lab=VcbN}
N 1610 1022.5 1610 1027.5 {lab=VcbN}
N 1610 1027.5 1730 1027.5 {lab=VcbN}
N 440 877.5 445 877.5 {lab=0}
N 440 717.5 440 737.5 {lab=#net4}
N 440 822.5 440 847.5 {lab=Vg1P}
N 375 672.5 400 672.5 {lab=VinPDr}
N 375 777.5 400 777.5 {lab=VinPDr}
N 375 877.5 400 877.5 {lab=VinPDr}
N 375 842.5 375 877.5 {lab=VinPDr}
N 785 877.5 810 877.5 {lab=VinNDr}
N 810 842.5 810 877.5 {lab=VinNDr}
N 750 717.5 750 737.5 {lab=#net5}
N 650 622.5 750 622.5 {lab=VH}
N 790 672.5 810 672.5 {lab=VinNDr}
N 790 777.5 810 777.5 {lab=VinNDr}
N 810 687.5 810 767.5 {lab=VinNDr}
N 810 792.5 810 842.5 {lab=VinNDr}
N 750 832.5 750 847.5 {lab=Vg1N}
N 515 672.5 520 672.5 {lab=Vdd}
N 660 672.5 670 672.5 {lab=Vdd}
N 660 877.5 665 877.5 {lab=Vdd}
N 545 877.5 550 877.5 {lab=Vdd}
N 375 687.5 375 767.5 {lab=VinPDr}
N 440 622.5 490 622.5 {lab=VH}
N 750 807.5 750 817.5 {lab=Vg1N}
N 375 792.5 375 842.5 {lab=VinPDr}
N 440 907.5 440 942.5 {lab=VL}
N 545 907.5 545 942.5 {lab=VL}
N 660 907.5 660 942.5 {lab=VL}
N 750 907.5 750 942.5 {lab=VL}
N 490 622.5 575 622.5 {lab=VH}
N 625 942.5 750 942.5 {lab=VL}
N 440 942.5 570 942.5 {lab=VL}
N 625 622.5 650 622.5 {lab=VH}
N 435 672.5 440 672.5 {lab=Vdd}
N 520 702.5 520 717.5 {lab=#net4}
N 440 717.5 520 717.5 {lab=#net4}
N 440 702.5 440 717.5 {lab=#net4}
N 375 672.5 375 687.5 {lab=VinPDr}
N 750 702.5 750 717.5 {lab=#net5}
N 810 672.5 810 687.5 {lab=VinNDr}
N 750 672.5 755 672.5 {lab=Vdd}
N 665 717.5 750 717.5 {lab=#net5}
N 440 807.5 440 822.5 {lab=Vg1P}
N 375 777.5 375 792.5 {lab=VinPDr}
N 750 817.5 750 832.5 {lab=Vg1N}
N 810 777.5 810 792.5 {lab=VinNDr}
N 440 737.5 440 747.5 {lab=#net4}
N 750 737.5 750 747.5 {lab=#net5}
N 810 767.5 810 777.5 {lab=VinNDr}
N 375 767.5 375 777.5 {lab=VinPDr}
N 440 807.5 545 807.5 {lab=Vg1P}
N 660 807.5 750 807.5 {lab=Vg1N}
N 570 942.5 625 942.5 {lab=VL}
N 575 622.5 625 622.5 {lab=VH}
N 545 807.5 660 847.5 {lab=Vg1P}
N 545 847.5 660 807.5 {lab=Vg1N}
N 505 877.5 505 907.5 {lab=VinPDr}
N 505 907.5 505 912.5 {lab=VinPDr}
N 505 912.5 505 917.5 {lab=VinPDr}
N 375 917.5 505 917.5 {lab=VinPDr}
N 375 877.5 375 917.5 {lab=VinPDr}
N 700 877.5 700 917.5 {lab=VinNDr}
N 700 917.5 810 917.5 {lab=VinNDr}
N 810 877.5 810 917.5 {lab=VinNDr}
N 750 622.5 750 637.5 {lab=VH}
N 750 637.5 750 642.5 {lab=VH}
N 665 622.5 665 642.5 {lab=VH}
N 520 622.5 520 642.5 {lab=VH}
N 440 622.5 440 642.5 {lab=VH}
N 745 877.5 750 877.5 {lab=0}
N 750 777.5 755 777.5 {lab=Vdd}
N 435 777.5 440 777.5 {lab=Vdd}
N 560 672.5 580 672.5 {lab=VinNDr}
N 580 672.5 635 732.5 {lab=VinNDr}
N 665 702.5 665 712.5 {lab=#net5}
N 665 712.5 665 717.5 {lab=#net5}
N 605 672.5 625 672.5 {lab=VinPDr}
N 555 732.5 605 672.5 {lab=VinPDr}
N 1420 1100 1420 1102.5 {lab=VoutN}
N 1275 1110 1275 1132.5 {lab=VoutP}
N 1420 895 1420 930 {lab=#net1}
N 1420 1025 1420 1035 {lab=VxN}
N 1420 1020 1420 1025 {lab=VxN}
N 1275 1020 1275 1035 {lab=VxP}
N 1275 895 1275 930 {lab=#net1}
N 1420 1267.5 1420 1292.5 {lab=VoutN}
N 377.5 732.5 555 732.5 {lab=VinPDr}
N 375 732.5 377.5 732.5 {lab=VinPDr}
N 635 732.5 810 732.5 {lab=VinNDr}
N 1125 1157.5 1125 1245 {lab=Vg1P}
N 1570 1157.5 1570 1250 {lab=Vg1N}
N 1125 1245 1125 1247.5 {lab=Vg1P}
N 1132.5 835 1272.5 835 {lab=#net6}
N 1412.5 835 1552.5 835 {lab=#net6}
N 1272.5 600 1272.5 635 {lab=Vdd}
N 1272.5 695 1272.5 715 {lab=#net7}
N 1272.5 775 1272.5 835 {lab=#net6}
N 1412.5 600 1412.5 635 {lab=Vdd}
N 1412.5 695 1412.5 715 {lab=#net8}
N 1412.5 775 1412.5 835 {lab=#net6}
N 1552.5 600 1552.5 635 {lab=Vdd}
N 1552.5 695 1552.5 715 {lab=#net9}
N 1552.5 775 1552.5 835 {lab=#net6}
N 1132.5 600 1132.5 635 {lab=Vdd}
N 1132.5 695 1132.5 715 {lab=#net10}
N 1132.5 775 1132.5 835 {lab=#net6}
N 1272.5 835 1412.5 835 {lab=#net6}
N 1345 835 1345 837.5 {lab=#net6}
N 1345 892.5 1345 895 {lab=#net1}
N 202.5 790 210 790 {lab=VinNDr}
N 202.5 700 210 700 {lab=VinPDr}
N 1992.5 962.5 1992.5 987.5 {lab=#net11}
N 2032.5 812.5 2092.5 812.5 {lab=VPMir}
N 1992.5 842.5 1992.5 852.5 {lab=VPMir}
N 2032.5 812.5 2032.5 852.5 {lab=VPMir}
N 1992.5 1047.5 1992.5 1077.5 {lab=0}
N 1992.5 852.5 1992.5 902.5 {lab=VPMir}
N 2032.5 727.5 2092.5 727.5 {lab=VPCas}
N 1992.5 757.5 1992.5 782.5 {lab=#net12}
N 1992.5 852.5 2032.5 852.5 {lab=VPMir}
N 1992.5 672.5 1992.5 698.75 {lab=Vdd}
N 2188.75 882.5 2188.75 902.5 {lab=#net13}
N 2188.75 962.5 2188.75 987.5 {lab=#net14}
N 2188.75 1047.5 2188.75 1077.5 {lab=0}
N 2188.75 807.5 2188.75 822.5 {lab=Vdd}
N 2228.75 852.5 2228.75 882.5 {lab=#net13}
N 2188.75 882.5 2228.75 882.5 {lab=#net13}
N 2226.25 852.5 2228.75 852.5 {lab=#net13}
N 2313.75 807.5 2313.75 822.5 {lab=Vdd}
N 2313.75 950 2353.75 950 {lab=IB10}
N 2313.75 950 2313.75 951.25 {lab=IB10}
N 2313.75 881.25 2313.75 950 {lab=IB10}
N 2351.25 980 2353.75 980 {lab=IB10}
N 2188.75 852.5 2192.5 852.5 {lab=Vdd}
N 2310 852.5 2313.75 852.5 {lab=Vdd}
N 2312.5 980 2317.5 980 {lab=0}
N 2353.75 950 2353.75 980 {lab=IB10}
N 2353.75 980 2378.75 980 {lab=IB10}
N 2228.75 932.5 2228.75 963.75 {lab=VNMir}
N 2228.75 963.75 2228.75 971.25 {lab=VNMir}
N 2032.5 932.5 2032.5 971.25 {lab=VNMir}
N 2228.75 1017.5 2228.75 1055 {lab=VNCas}
N 2032.5 1017.5 2032.5 1055 {lab=VNCas}
N 2313.75 1010 2313.75 1041.25 {lab=0}
N 2313.75 1041.25 2313.75 1042.5 {lab=0}
N 2228.75 852.5 2273.75 852.5 {lab=#net13}
N 2187.5 807.5 2313.75 807.5 {lab=Vdd}
N 2032.5 971.25 2228.75 971.25 {lab=VNMir}
N 2032.5 1055 2228.75 1055 {lab=VNCas}
C {symbols/pfet_03v3.sym} 1255 960 0 0 {name=M11
L=0.28u
W=\{cswW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1440 960 0 1 {name=M12
L=0.28u
W=\{cswW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1275 960 0 1 {name=p13 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1415 960 0 0 {name=p14 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1255 1065 0 0 {name=M17
L=0.28u
W=\{cbufW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1280 1065 0 1 {name=p15 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1440 1065 0 1 {name=M18
L=0.28u
W=\{cbufW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1415 1065 0 0 {name=p16 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1550 1157.5 0 1 {name=M62
L=0.28u
W=\{invPw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1530 1157.5 0 0 {name=p25 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1530 1247.5 1 1 {name=l3 lab=0}
C {symbols/nfet_03v3.sym} 1550 1247.5 0 1 {name=M69
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1530 1292.5 0 0 {name=l6 lab=0}
C {symbols/pfet_03v3.sym} 1440 1202.5 0 1 {name=M70
L=0.28u
W=\{dummyW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1415 1202.5 0 0 {name=p108 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1145 1157.5 0 0 {name=M72
L=0.28u
W=\{invPw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1165 1157.5 0 1 {name=p118 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1165 1247.5 3 0 {name=l7 lab=0}
C {symbols/nfet_03v3.sym} 1145 1247.5 0 0 {name=M127
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1165 1292.5 0 1 {name=l9 lab=0}
C {symbols/pfet_03v3.sym} 1255 1202.5 0 0 {name=M128
L=0.28u
W=\{dummyW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1280 1202.5 0 1 {name=p119 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 1165 1112.5 0 0 {name=p120 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 1530 1112.5 0 0 {name=p123 sig_type=std_logic lab=Vdd}
C {gnd.sym} 910 1185 0 0 {name=l1 lab=0}
C {vsource.sym} 910 1155 0 0 {name=VcbRef value=\{Vcbias\} savecurrent=true}
C {lab_pin.sym} 910 1110 0 1 {name=p113 sig_type=std_logic lab=VcbRef}
C {lab_pin.sym} 1460 1065 2 0 {name=p10 sig_type=std_logic lab=VcbN}
C {param.sym} 850 1092.5 0 0 {name=s4 value="VcBias=0.88"
}
C {lab_pin.sym} 1275 1012.5 2 1 {name=p9 sig_type=std_logic lab=VxP}
C {lab_pin.sym} 1420 1012.5 0 0 {name=p11 sig_type=std_logic lab=VxN}
C {lab_pin.sym} 1085 960 2 0 {name=p18 sig_type=std_logic lab=VcbP}
C {lab_pin.sym} 965 920 0 0 {name=p32 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 965 940 2 1 {name=p36 sig_type=std_logic lab=VcbRef}
C {lab_pin.sym} 1235 1065 0 0 {name=p26 sig_type=std_logic lab=VcbP}
C {lab_pin.sym} 1610 957.5 0 0 {name=p28 sig_type=std_logic lab=VcbN}
C {lab_pin.sym} 1730 917.5 2 0 {name=p42 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1730 937.5 0 1 {name=p43 sig_type=std_logic lab=VcbRef}
C {cellv9/ota5_ab_buf_v1.sym} 985 1090 0 0 {name=x1}
C {cellv9/ota5_ab_buf_v1.sym} 1710 1087.5 0 1 {name=x2}
C {symbols/pfet_03v3.sym} 420 672.5 0 0 {name=M7
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 420 777.5 0 0 {name=M13
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 420 877.5 0 0 {name=M14
L=0.28u
W=\{cmLw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 445 877.5 3 0 {name=l8 lab=0}
C {symbols/pfet_03v3.sym} 540 672.5 0 1 {name=M15
L=0.28u
W=\{cmHfbW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 770 672.5 0 1 {name=M16
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 770 777.5 0 1 {name=M24
L=0.28u
W=\{cmHw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 770 877.5 0 1 {name=M29
L=0.28u
W=\{cmLw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 745 877.5 1 1 {name=l10 lab=0}
C {symbols/pfet_03v3.sym} 645 672.5 0 0 {name=M30
L=0.28u
W=\{cmHfbW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 525 877.5 0 0 {name=M31
L=0.28u
W=\{cmLfbw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 680 877.5 0 1 {name=M32
L=0.28u
W=\{cmLfbw\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 550 877.5 0 1 {name=p17 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 665 877.5 0 0 {name=p19 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 545 807.5 0 0 {name=p24 sig_type=std_logic lab=Vg1P}
C {lab_wire.sym} 730 807.5 0 0 {name=p40 sig_type=std_logic lab=Vg1N}
C {lab_wire.sym} 515 672.5 0 0 {name=p41 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 575 622.5 0 1 {name=p45 sig_type=std_logic lab=VH}
C {lab_wire.sym} 440 672.5 0 1 {name=p46 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 665 672.5 0 1 {name=p47 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 750 672.5 0 0 {name=p48 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 440 777.5 0 1 {name=p49 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 750 777.5 0 0 {name=p50 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 810 725 2 0 {name=p51 sig_type=std_logic lab=VinNDr}
C {lab_pin.sym} 375 727.5 2 1 {name=p52 sig_type=std_logic lab=VinPDr}
C {lab_wire.sym} 595 942.5 0 1 {name=p53 sig_type=std_logic lab=VL}
C {param.sym} 377.5 587.5 0 0 {name=s3 value="cmLw=0.4u"
}
C {param.sym} 377.5 567.5 0 0 {name=s6 value="cmHw=0.6u"
}
C {param.sym} 617.5 587.5 0 0 {name=s7 value="cmLfbw=2.0u"
}
C {param.sym} 617.5 567.5 0 0 {name=s14 value="cmHfbw=0.22u"
}
C {lab_pin.sym} 1235 960 2 1 {name=p4 sig_type=std_logic lab=Vg1P}
C {lab_pin.sym} 1460 960 0 1 {name=p6 sig_type=std_logic lab=Vg1N}
C {lab_pin.sym} 1275 1297.5 2 0 {name=p29 sig_type=std_logic lab=VoutP}
C {lab_pin.sym} 1420 1292.5 0 0 {name=p31 sig_type=std_logic lab=VoutN}
C {lab_pin.sym} 1125 1200 2 1 {name=p37 sig_type=std_logic lab=Vg1P}
C {lab_pin.sym} 1570 1200 0 1 {name=p38 sig_type=std_logic lab=Vg1N}
C {param.sym} 1340 550 0 0 {name=s8 value="dummyW=0.9u"
}
C {param.sym} 1340 525 0 0 {name=s9 value="invPW=0.45u"
}
C {param.sym} 1090 530 0 0 {name=s10 value="cswW=3.0u"
}
C {param.sym} 1090 550 0 0 {name=s11 value="cbufW=3.0u"
}
C {cellv9/clamp.sym} 492.5 1017.5 0 0 {name=x3}
C {lab_wire.sym} 592.5 1007.5 0 1 {name=p27 sig_type=std_logic lab=VH}
C {lab_wire.sym} 592.5 1027.5 0 1 {name=p39 sig_type=std_logic lab=VL}
C {lab_wire.sym} 392.5 1007.5 0 0 {name=p44 sig_type=std_logic lab=Vdd}
C {opin.sym} 430 345 0 0 {name=p80 lab=VoutP}
C {opin.sym} 432.5 370 0 0 {name=p81 lab=VoutN}
C {ipin.sym} 387.5 345 0 0 {name=p84 lab=VinP}
C {ipin.sym} 390 372.5 0 0 {name=p85 lab=VinN}
C {ipin.sym} 390 470 0 0 {name=p129 lab=Vdd}
C {ipin.sym} 390 397.5 0 0 {name=p130 lab=VPCas}
C {ipin.sym} 390 425 0 0 {name=p131 lab=VNCas}
C {ipin.sym} 390 447.5 0 0 {name=p69 lab=VNMir}
C {symbols/pfet_03v3.sym} 1252.5 665 0 0 {name=M9
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1252.5 745 0 0 {name=M10
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1272.5 665 0 1 {name=p12 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1272.5 745 0 1 {name=p30 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1232.5 745 2 1 {name=p33 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1232.5 665 2 1 {name=p34 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1272.5 600 2 1 {name=p35 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1392.5 665 0 0 {name=M20
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1392.5 745 0 0 {name=M21
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1412.5 665 0 1 {name=p70 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1412.5 745 0 1 {name=p71 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1372.5 745 2 1 {name=p72 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1372.5 665 2 1 {name=p73 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1412.5 600 2 1 {name=p74 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1532.5 665 0 0 {name=M22
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1532.5 745 0 0 {name=M23
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1552.5 665 0 1 {name=p75 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1552.5 745 0 1 {name=p76 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1512.5 745 2 1 {name=p77 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1512.5 665 2 1 {name=p78 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1552.5 600 2 1 {name=p79 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 1112.5 665 0 0 {name=M33
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1112.5 745 0 0 {name=M34
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1132.5 665 0 1 {name=p82 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1132.5 745 0 1 {name=p83 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 1092.5 745 2 1 {name=p86 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 1092.5 665 2 1 {name=p87 sig_type=std_logic lab=VPCas}
C {lab_pin.sym} 1132.5 600 2 1 {name=p88 sig_type=std_logic lab=Vdd}
C {ammeter.sym} 1345 865 0 0 {name=Vcx savecurrent=true spice_ignore=0}
C {ammeter.sym} 112.5 790 3 0 {name=VinN savecurrent=true spice_ignore=0}
C {common/cmos_buf.sym} 22.5 800 0 0 {name=x5}
C {lab_pin.sym} -17.5 780 2 1 {name=p1 sig_type=std_logic lab=VinN}
C {lab_pin.sym} -17.5 800 2 1 {name=p2 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 210 790 0 1 {name=p3 sig_type=std_logic lab=VinNDr}
C {ammeter.sym} 112.5 700 3 0 {name=VinP savecurrent=true spice_ignore=0}
C {common/cmos_buf.sym} 22.5 710 0 0 {name=x4}
C {lab_pin.sym} -17.5 690 2 1 {name=p5 sig_type=std_logic lab=VinP}
C {lab_pin.sym} -17.5 710 2 1 {name=p7 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 210 700 0 1 {name=p8 sig_type=std_logic lab=VinPDr}
C {lab_pin.sym} 1730 897.5 2 0 {name=p58 sig_type=std_logic lab=IB10}
C {lab_pin.sym} 965 900 2 1 {name=p62 sig_type=std_logic lab=IB10}
C {symbols/ppolyf_u_1k.sym} 172.5 700 3 0 {name=R3
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 172.5 790 1 0 {name=R1
W=1e-6
L=1e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 172.5 720 2 0 {name=p107 sig_type=std_logic lab=Vdd}
C {lab_wire.sym} 172.5 770 0 0 {name=p63 sig_type=std_logic lab=Vdd}
C {param.sym} 1946.25 582.5 0 0 {name=s5 value="casW=4u"
}
C {param.sym} 1948.75 557.5 0 0 {name=s1 value="mirW=4u"
}
C {param.sym} 1948.75 535 0 0 {name=s2 value="mirL=1u"
}
C {param.sym} 1951.25 605 0 0 {name=s12 value="casL=1u"
}
C {gnd.sym} 1992.5 932.5 1 1 {name=l2 lab=0}
C {symbols/nfet_03v3.sym} 2012.5 932.5 0 1 {name=M2
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2012.5 812.5 0 1 {name=M3
L=\{mirL\}
W=\{mirW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1992.5 812.5 0 0 {name=p64 sig_type=std_logic lab=Vdd}
C {gnd.sym} 1992.5 1017.5 1 1 {name=l11 lab=0}
C {symbols/nfet_03v3.sym} 2012.5 1017.5 0 1 {name=M19
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1992.5 1077.5 0 1 {name=l13 lab=0}
C {symbols/pfet_03v3.sym} 2012.5 727.5 0 1 {name=M4
L=\{casL\}
W=\{casW\}
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1992.5 727.5 0 0 {name=p65 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2057.5 872.5 0 1 {name=l23 lab=0}
C {lab_pin.sym} 1992.5 672.5 1 0 {name=p66 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2032.5 1017.5 0 1 {name=p67 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 2032.5 932.5 0 1 {name=p68 sig_type=std_logic lab=VNMir}
C {lab_pin.sym} 2091.25 812.5 2 0 {name=p90 sig_type=std_logic lab=VPMir}
C {lab_pin.sym} 2092.5 727.5 2 0 {name=p91 sig_type=std_logic lab=VPCas}
C {gnd.sym} 2188.75 932.5 1 1 {name=l21 lab=0}
C {symbols/nfet_03v3.sym} 2208.75 932.5 0 1 {name=M36
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2188.75 1017.5 1 1 {name=l22 lab=0}
C {symbols/nfet_03v3.sym} 2208.75 1017.5 0 1 {name=M37
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2188.75 1077.5 0 1 {name=l24 lab=0}
C {lab_pin.sym} 2228.75 1017.5 0 1 {name=p92 sig_type=std_logic lab=VNCas}
C {lab_pin.sym} 2228.75 932.5 0 1 {name=p95 sig_type=std_logic lab=VNMir}
C {symbols/pfet_03v3.sym} 2208.75 852.5 0 1 {name=M38
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 2188.75 807.5 1 0 {name=p96 sig_type=std_logic lab=Vdd}
C {symbols/pfet_03v3.sym} 2293.75 852.5 0 0 {name=M39
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2333.75 980 0 1 {name=M40
L=1u
W=8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2313.75 1042.5 0 1 {name=l25 lab=0}
C {lab_pin.sym} 2378.75 980 2 0 {name=p97 sig_type=std_logic lab=IB10}
C {lab_pin.sym} 2188.75 852.5 0 0 {name=p98 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2312.5 852.5 2 0 {name=p99 sig_type=std_logic lab=Vdd}
C {gnd.sym} 2312.5 980 1 1 {name=l26 lab=0}
C {gnd.sym} 2367.5 1040 0 1 {name=l27 lab=0}
C {symbols/cap_mim_analog.sym} 2057.5 842.5 0 0 {name=C4
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1}
C {symbols/cap_mim_analog.sym} 2367.5 1010 0 0 {name=C2
W=25e-6
L=20e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1}
