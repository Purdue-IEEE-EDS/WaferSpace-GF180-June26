v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 20 -80 40 -80 {lab=0}
N 20 -80 20 -20 {lab=0}
N 20 -20 40 -20 {lab=0}
C {symbols/pplus_u.sym} 40 -50 0 0 {name=R1
W=5e-6
L=20e-6
model=pplus_u
spiceprefix=X
m=1}
C {gnd.sym} 40 -20 0 0 {name=l1 lab=0}
